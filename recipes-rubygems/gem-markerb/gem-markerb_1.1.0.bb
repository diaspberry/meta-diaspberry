SUMMARY = "markerb - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "markerb"
HOMEPAGE = "http://rubygems.org/gems/markerb"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=e344ed56b94175d599c37d66683ae429"


SRC_URI[md5sum] = "2bee0ad803a4ab9d8aa1a19004d9aa96"
SRC_URI[sha256sum] = "e678328edffe737e4b126a19df6b3853c833b56742c7a40035080ce6d41c5523"

PR = "r0"

inherit rubygems
