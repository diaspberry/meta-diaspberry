SUMMARY = "rails-assets-markdown-it - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-markdown-it"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-markdown-it"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "4cc92873f21cf4d7a963ebf7ebe9253c"
SRC_URI[sha256sum] = "20c0cfef10fbee6177638910d36e664babd99163ef461e035b81ed94b9819354"

PR = "r0"

inherit rubygems
