SUMMARY = "rails-assets-blueimp-gallery - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-blueimp-gallery"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-blueimp-gallery"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "b57e73d308992bf7af737fec307f641d"
SRC_URI[sha256sum] = "1db3d14ea49970c3b692fe525c3811068a2ef0febeaa37a105f4059db9a2621c"

PR = "r0"

inherit rubygems
