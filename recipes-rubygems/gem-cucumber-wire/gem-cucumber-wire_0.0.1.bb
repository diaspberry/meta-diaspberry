SUMMARY = "cucumber-wire - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "cucumber-wire"
HOMEPAGE = "http://rubygems.org/gems/cucumber-wire"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "875d967d513d5906214744a82409621c"
SRC_URI[sha256sum] = "4ea8ca3f772d80876eb50533ab10521b383d866419bd6e838b822f0d16ded527"

PR = "r0"

inherit rubygems
