SUMMARY = "multi_test - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "multi_test"
HOMEPAGE = "http://rubygems.org/gems/multi_test"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=9a4c9c3144063756a642d1876234ea35"


SRC_URI[md5sum] = "fe8eba2f7ff9f6190bccf763433e2c59"
SRC_URI[sha256sum] = "adfbe09decee22deea2dc7a6b60698766306d3e74e9af0e03199de80b029a3eb"

PR = "r0"

inherit rubygems
