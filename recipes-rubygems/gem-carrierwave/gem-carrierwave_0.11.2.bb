SUMMARY = "carrierwave - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "carrierwave"
HOMEPAGE = "http://rubygems.org/gems/carrierwave"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "f0fb09a5017d0817481a3db2f56133eb"
SRC_URI[sha256sum] = "6faee619e9fe56e84e0a17a8bf7284d4ecd14775da58c64b98ddaecedec6514b"

PR = "r0"

inherit rubygems
