SUMMARY = "rails-assets-jasmine - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-jasmine"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-jasmine"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "5e7c79ebad9d30750adf16c59704a078"
SRC_URI[sha256sum] = "de08ca07631653c9e1e1d8b9c49466318e68972eaef18d3f7fa2afd2de1225ab"

PR = "r0"

inherit rubygems
