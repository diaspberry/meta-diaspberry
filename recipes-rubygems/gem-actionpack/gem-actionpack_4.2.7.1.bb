SUMMARY = "actionpack - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "actionpack"
HOMEPAGE = "http://rubygems.org/gems/actionpack"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=c1a401c5778f1549ecfe3452a26d6c19"


SRC_URI[md5sum] = "c0be814a9566ced2d70afa9a69d54d2e"
SRC_URI[sha256sum] = "907ef4d99d20924be556019fea329e8ed2f42be0fa8700ba9235ce4af72a5ee5"

PR = "r0"

inherit rubygems
