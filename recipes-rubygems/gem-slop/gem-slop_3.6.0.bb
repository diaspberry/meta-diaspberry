SUMMARY = "slop - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "slop"
HOMEPAGE = "http://rubygems.org/gems/slop"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=66a8da2a5bee25570ffc35aa5426d176"


SRC_URI[md5sum] = "ee7f34f31a61cc1ef0327ae424d7a4cf"
SRC_URI[sha256sum] = "76ccab03be66bfcab4838cdc07cab019cd3e192a3538266246749e79e4788803"

PR = "r0"

inherit rubygems
