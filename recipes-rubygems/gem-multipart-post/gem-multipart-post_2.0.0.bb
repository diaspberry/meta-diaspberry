SUMMARY = "multipart-post - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "multipart-post"
HOMEPAGE = "http://rubygems.org/gems/multipart-post"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "1be431f2e8b50cc5b63cc7b7e23fef44"
SRC_URI[sha256sum] = "3dc44e50d3df3d42da2b86272c568fd7b75c928d8af3cc5f9834e2e5d9586026"

PR = "r0"

inherit rubygems
