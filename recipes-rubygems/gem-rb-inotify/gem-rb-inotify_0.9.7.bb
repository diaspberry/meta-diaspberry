SUMMARY = "rb-inotify - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rb-inotify"
HOMEPAGE = "http://rubygems.org/gems/rb-inotify"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=e08182ac8a7bc29b7caea44510086d7f"


SRC_URI[md5sum] = "9f960a580af3cc0cabb006eb52d854a5"
SRC_URI[sha256sum] = "2d9c1bf013d2f9e62b4fe827286ce77c35c83f06b65749a95a08d862c0b8ccf9"

PR = "r0"

inherit rubygems
