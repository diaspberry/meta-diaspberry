SUMMARY = "compass-import-once - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "compass-import-once"
HOMEPAGE = "http://rubygems.org/gems/compass-import-once"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=aee65e2d0ffecd09add0ae382f21163e"


SRC_URI[md5sum] = "2197cae9d2fa582007391f5ae60ad52b"
SRC_URI[sha256sum] = "38978ffed0d332e8526e87e1befd1b6831774ca7d8350c5adb5b9eef167fc72e"

PR = "r0"

inherit rubygems
