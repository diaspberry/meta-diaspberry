SUMMARY = "phantomjs - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "phantomjs"
HOMEPAGE = "http://rubygems.org/gems/phantomjs"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c7dc4b2370c75f33c71a85cadf4867e3"


SRC_URI[md5sum] = "1c9c5f29d0f527ca5ff453d81faf3e0e"
SRC_URI[sha256sum] = "b392cfba33d374285d022c905c714948fc1a69d162cd17cfea39b684fd5a1779"

PR = "r0"

inherit rubygems
