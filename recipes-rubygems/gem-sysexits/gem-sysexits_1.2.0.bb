SUMMARY = "sysexits - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sysexits"
HOMEPAGE = "http://rubygems.org/gems/sysexits"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ab6e3fb0a445326f74907f1820f6a61a"


SRC_URI[md5sum] = "220a9ccceddee029b4d302c1f07ce610"
SRC_URI[sha256sum] = "598241c4ae57baa403c125182dfdcc0d1ac4c0fb606dd47fbed57e4aaf795662"

PR = "r0"

inherit rubygems
