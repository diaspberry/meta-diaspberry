SUMMARY = "bootstrap-switch-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "bootstrap-switch-rails"
HOMEPAGE = "http://rubygems.org/gems/bootstrap-switch-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=da1a653899a4dd616bc98e00af62ba59"


SRC_URI[md5sum] = "b75c94dfa1901fc71885bf17e08388e2"
SRC_URI[sha256sum] = "94842c98caa7bfeda355d5f26c2f73175706e62f6a4f9a2ca816c6ea60607cfe"

PR = "r0"

inherit rubygems
