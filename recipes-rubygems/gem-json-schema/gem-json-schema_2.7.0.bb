SUMMARY = "json-schema - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "json-schema"
HOMEPAGE = "http://rubygems.org/gems/json-schema"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=ea01c3bde29ebea5b956cb624610427b"


SRC_URI[md5sum] = "e63d8472fc64847d42931f79ff4d1ad0"
SRC_URI[sha256sum] = "78dcc3972692cf5a4ce0b0329c241fc2b6aa2cdf41fcc006aa1740183e5da342"

PR = "r0"

inherit rubygems
