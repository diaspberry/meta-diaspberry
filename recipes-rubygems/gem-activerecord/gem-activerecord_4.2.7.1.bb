SUMMARY = "activerecord - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "activerecord"
HOMEPAGE = "http://rubygems.org/gems/activerecord"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=81b3601494b8bbd884f94c867713c6a2"


SRC_URI[md5sum] = "ba4e0fe34d4aeea85043daef72b88a63"
SRC_URI[sha256sum] = "923a64e2ebb9c4529761bf65ed37601a7000af2f3b18f12ea00e9f9ba2a168d2"

PR = "r0"

inherit rubygems
