SUMMARY = "execjs - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "execjs"
HOMEPAGE = "http://rubygems.org/gems/execjs"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=9a411ef0cea200b7999ca908294c26a5"


SRC_URI[md5sum] = "b70a025a95390656409dcbc748c87fa6"
SRC_URI[sha256sum] = "e1fae0c5c831934c47d92363b4ea66ef2951350ab91b5d8d3174342b9c2ee5fb"

PR = "r0"

inherit rubygems
