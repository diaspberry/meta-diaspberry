SUMMARY = "pronto-haml - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "pronto-haml"
HOMEPAGE = "http://rubygems.org/gems/pronto-haml"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b0be4887c19ae74609f7ff9ca57ebb7c"


SRC_URI[md5sum] = "66f1c84efd1d17c1153747650abd94ce"
SRC_URI[sha256sum] = "f24f101f37a576135cee262bcac4062e8439d38507c82fd42d2729f2a19f0a47"

PR = "r0"

inherit rubygems
