SUMMARY = "ethon - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "ethon"
HOMEPAGE = "http://rubygems.org/gems/ethon"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=51dc9f071fc9da721ef7e967f87f2c15"


SRC_URI[md5sum] = "a9ccbd9058a06bc841c43d98b69ba0eb"
SRC_URI[sha256sum] = "c6b19fc2590a701b860f76ac1aee6fa5cde4a08dbf289c0a42c359f8c7b6758d"

PR = "r0"

inherit rubygems
