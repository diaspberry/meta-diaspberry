SUMMARY = "fog - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog"
HOMEPAGE = "http://rubygems.org/gems/fog"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=b60134f3d14f00f3b2e3474600e2bdbc"


SRC_URI[md5sum] = "1fc23975caeca4187968058a6478a5ef"
SRC_URI[sha256sum] = "f1e1d8126b909e187d29f4dff97039bbb4236aac2293fda3b887e8325aef0fa6"

PR = "r0"

inherit rubygems
