SUMMARY = "oauth - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "oauth"
HOMEPAGE = "http://rubygems.org/gems/oauth"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=755b72a0d004675c51ffe503df5c8664"


SRC_URI[md5sum] = "5aa7b77c8e35713a59da8e5c2c49f20b"
SRC_URI[sha256sum] = "7e0a43c527af605dc1fc3ef8416d2641b400078d8a22e30981ac47d81af290ab"

PR = "r0"

inherit rubygems
