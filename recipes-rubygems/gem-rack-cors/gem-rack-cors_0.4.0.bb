SUMMARY = "rack-cors - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-cors"
HOMEPAGE = "http://rubygems.org/gems/rack-cors"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=046b45f91e30a2488614de27bcb59094"


SRC_URI[md5sum] = "4745703d4ce7b0ebb5e29830fc4a4aa2"
SRC_URI[sha256sum] = "7c8609d980027578597c675c8d66096286059311f3b70607955bec2a5f6ae9eb"

PR = "r0"

inherit rubygems
