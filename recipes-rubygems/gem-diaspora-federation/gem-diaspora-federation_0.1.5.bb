SUMMARY = "diaspora_federation - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "diaspora_federation"
HOMEPAGE = "http://rubygems.org/gems/diaspora_federation"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6ba6a7f44428f5b06245f2079a852275"


SRC_URI[md5sum] = "98baf67c0433c25796cc5cf258f34216"
SRC_URI[sha256sum] = "0a3a9091ab8b401ba31b5b3361558db1286aa21bb3063b887096f5d69daccb55"

PR = "r0"

inherit rubygems
