SUMMARY = "i18n-inflector - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "i18n-inflector"
HOMEPAGE = "http://rubygems.org/gems/i18n-inflector"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LGPL-LICENSE;md5=395e44694624b7b27173ea0c427ad53c"


SRC_URI[md5sum] = "f6f9281be18a5d2d27e502c25f2f502d"
SRC_URI[sha256sum] = "efb08a22a96405dd246aaf92f9b82c40c42e130741bb75ab93581d92fec93220"

PR = "r0"

inherit rubygems
