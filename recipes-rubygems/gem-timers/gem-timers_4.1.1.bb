SUMMARY = "timers - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "timers"
HOMEPAGE = "http://rubygems.org/gems/timers"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=69f8e278bb4968badb0504533fa85fd2"


SRC_URI[md5sum] = "e988fad2ddbfd2ff20945b9358617004"
SRC_URI[sha256sum] = "8ccb9a3918a57e0aca8fb52516b4d89b86c553f3df002d4be32bcd4ce2356ce9"

PR = "r0"

inherit rubygems
