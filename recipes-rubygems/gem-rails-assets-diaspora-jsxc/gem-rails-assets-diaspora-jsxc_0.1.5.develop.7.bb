SUMMARY = "rails-assets-diaspora_jsxc - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-diaspora_jsxc"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-diaspora_jsxc"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "219661bedfcaeb981aa6441074373946"
SRC_URI[sha256sum] = "11da42ab599bd1df6802c094a69caf71b927855a90692d9a23523b44816c781f"

PR = "r0"

inherit rubygems
