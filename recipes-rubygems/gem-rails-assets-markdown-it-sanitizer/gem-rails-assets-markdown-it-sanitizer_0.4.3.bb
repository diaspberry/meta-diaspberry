SUMMARY = "rails-assets-markdown-it-sanitizer - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-markdown-it-sanitizer"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-markdown-it-sanitizer"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "e937d3fa6326c336096b25050f36718b"
SRC_URI[sha256sum] = "66d856b0019c77dd7dd1203c0ad2574b7048e4482aaa3fff2982b981a073773a"

PR = "r0"

inherit rubygems
