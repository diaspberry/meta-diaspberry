SUMMARY = "uglifier - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "uglifier"
HOMEPAGE = "http://rubygems.org/gems/uglifier"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=31050542a772ccf08072030992562c8d"


SRC_URI[md5sum] = "de2dafb9245236e12630e7ba18970d79"
SRC_URI[sha256sum] = "ccc57a83cf6c0aacf41fe728edfdfef75e915e3accf75339e903cc304cd06038"

PR = "r0"

inherit rubygems
