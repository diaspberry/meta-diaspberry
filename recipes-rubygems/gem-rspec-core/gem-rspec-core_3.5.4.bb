SUMMARY = "rspec-core - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rspec-core"
HOMEPAGE = "http://rubygems.org/gems/rspec-core"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=3a5e8c0f5c7198772d1cfaa59805376d"


SRC_URI[md5sum] = "da331ca42abe7036dce4f79ea5dada47"
SRC_URI[sha256sum] = "d110ed5a57c54423b9db88896d4d495a067b2fdfc17d66ba43292f2c0cd04cd9"

PR = "r0"

inherit rubygems
