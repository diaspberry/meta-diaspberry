SUMMARY = "valid - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "valid"
HOMEPAGE = "http://rubygems.org/gems/valid"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "61dbe46e7af3256318bbd58df50a4412"
SRC_URI[sha256sum] = "a321b996b32ad5be6fc27020b477fd8b8129bf2adf9ac0852cd0f797667cb96f"

PR = "r0"

inherit rubygems
