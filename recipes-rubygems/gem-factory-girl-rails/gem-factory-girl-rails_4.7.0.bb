SUMMARY = "factory_girl_rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "factory_girl_rails"
HOMEPAGE = "http://rubygems.org/gems/factory_girl_rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f3281b4abd6e743ea1be56502c7c4aee"


SRC_URI[md5sum] = "0815610d8b3864c7a4471eeb5386a31f"
SRC_URI[sha256sum] = "99a84b9aa4d469c7283de47cf5207c59b208b663ab8648c857b8f531568ef743"

PR = "r0"

inherit rubygems
