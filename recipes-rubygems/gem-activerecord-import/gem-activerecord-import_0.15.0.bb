SUMMARY = "activerecord-import - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "activerecord-import"
HOMEPAGE = "http://rubygems.org/gems/activerecord-import"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=837b32593517ae48b9c3b5c87a5d288c"


SRC_URI[md5sum] = "53c3edb6f05efff95ac69fbaf16f3d81"
SRC_URI[sha256sum] = "58fead023ca121ffe7925e669a389cab55cae2b6027fc937b2ac84a96ff5eaf1"

PR = "r0"

inherit rubygems
