SUMMARY = "mobile-fu - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "mobile-fu"
HOMEPAGE = "http://rubygems.org/gems/mobile-fu"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=296fc6497a50bd4e01d653701add44e8"


SRC_URI[md5sum] = "803cbfa1adad5f802476cf9aac19860c"
SRC_URI[sha256sum] = "6e45f0f2deb884feb3ad39f6dba46a9928f3e213b55f51c8493a1a7c6fa8959d"

PR = "r0"

inherit rubygems
