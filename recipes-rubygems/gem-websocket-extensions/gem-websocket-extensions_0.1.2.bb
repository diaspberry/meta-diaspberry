SUMMARY = "websocket-extensions - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "websocket-extensions"
HOMEPAGE = "http://rubygems.org/gems/websocket-extensions"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "e20141d780ddf0557b30623e15e4c935"
SRC_URI[sha256sum] = "7919c0310edda55ce4026d3f160e612160493c048276cabe500308439dd2161f"

PR = "r0"

inherit rubygems
