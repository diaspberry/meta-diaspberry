SUMMARY = "swd - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "swd"
HOMEPAGE = "http://rubygems.org/gems/swd"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=313632713b5a258eb5c887c49679d182"


SRC_URI[md5sum] = "fcf296f4a4b68f22b41bd4afb4b4e33c"
SRC_URI[sha256sum] = "7c815b9dcd729bdc2a1ad5bd2d30c9b7429061c86cc72a619bb58d8fd88af984"

PR = "r0"

inherit rubygems
