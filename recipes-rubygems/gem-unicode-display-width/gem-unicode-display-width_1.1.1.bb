SUMMARY = "unicode-display_width - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "unicode-display_width"
HOMEPAGE = "http://rubygems.org/gems/unicode-display_width"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE.txt;md5=3f1a5820b4f1ef2ce7eee017d7a4d323"


SRC_URI[md5sum] = "f41ed1e559c75b4353218d47790608f6"
SRC_URI[sha256sum] = "3f3ac133a3040c607f3fa1d61867d49c0ce341c6d96063c2deeeab23f55835ac"

PR = "r0"

inherit rubygems
