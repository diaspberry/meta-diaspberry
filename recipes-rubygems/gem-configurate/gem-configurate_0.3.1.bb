SUMMARY = "configurate - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "configurate"
HOMEPAGE = "http://rubygems.org/gems/configurate"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=59113626178a1bd3fca0b45529970e3d"


SRC_URI[md5sum] = "3e74d87eb5e164491871fdfc8697091f"
SRC_URI[sha256sum] = "a1d9863471447cacaeba69f588b014175ab1857dbb1537188ff43849d6bdccd4"

PR = "r0"

inherit rubygems
