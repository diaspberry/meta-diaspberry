SUMMARY = "nio4r - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "nio4r"
HOMEPAGE = "http://rubygems.org/gems/nio4r"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=b1ac087f05ef366133599add6b8dc7f1"


SRC_URI[md5sum] = "3e3c7bbfc42a8ca412b5eade7d38d0ab"
SRC_URI[sha256sum] = "0a5a93676c7c116c51f00366800a7c039d67393dadb4b873059375d7cfa9b6a9"

PR = "r0"

inherit rubygems
