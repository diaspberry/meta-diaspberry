SUMMARY = "omniauth-tumblr - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "omniauth-tumblr"
HOMEPAGE = "http://rubygems.org/gems/omniauth-tumblr"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "43d05ddfe83a2512407b4935635e1ae1"
SRC_URI[sha256sum] = "fc242f9036e4e8675f97face5e247b6f41d5713d4f0072b132d35052bdabcc82"

PR = "r0"

inherit rubygems
