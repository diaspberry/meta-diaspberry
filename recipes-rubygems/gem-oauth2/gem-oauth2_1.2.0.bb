SUMMARY = "oauth2 - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "oauth2"
HOMEPAGE = "http://rubygems.org/gems/oauth2"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=5b9645bbb1efbe2b83c01c3b2a9b005f"


SRC_URI[md5sum] = "d3cfebe6cb3503db035aa85c062a515e"
SRC_URI[sha256sum] = "23a959386dae98f64ccac7a68c517666c611ff782477b3e1ff8c0b1451d7457c"

PR = "r0"

inherit rubygems
