SUMMARY = "bundler - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "bundler"
HOMEPAGE = "http://rubygems.org/gems/bundler"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=196bb963e601609817d7e9ac9a64a867"


SRC_URI[md5sum] = "44569534b9862cc134c8370714333ac8"
SRC_URI[sha256sum] = "a9f0c8c5cf977cadce77e6185695d4a0b956a73569a5634b15b34cc07fdb7bab"

PR = "r0"

inherit rubygems
