SUMMARY = "cucumber-api-steps - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "cucumber-api-steps"
HOMEPAGE = "http://rubygems.org/gems/cucumber-api-steps"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "908516ef6126a653d727d52dd6cf8b1d"
SRC_URI[sha256sum] = "b259287aedce713b04e7cd3db371395989c33bb37be92d99a3ffb93c25994dd7"

PR = "r0"

inherit rubygems
