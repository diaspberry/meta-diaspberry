SUMMARY = "httpclient - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "httpclient"
HOMEPAGE = "http://rubygems.org/gems/httpclient"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "c2c392cf9a574268a3f42f71264a8699"
SRC_URI[sha256sum] = "02d74c0c97ea7b6a53426213e8f316873d8aaf6ca11f963f9b6b15246404a6e4"

PR = "r0"

inherit rubygems
