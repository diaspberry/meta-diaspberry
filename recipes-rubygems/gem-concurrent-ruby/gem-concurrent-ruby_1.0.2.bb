SUMMARY = "concurrent-ruby - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "concurrent-ruby"
HOMEPAGE = "http://rubygems.org/gems/concurrent-ruby"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f8743706d9bd84f1b05c55d47756ef4f"


SRC_URI[md5sum] = "b40c7535b685bb7b5b32b729bb5a88bc"
SRC_URI[sha256sum] = "5c4b4cce37fc538660fae3b9fb7b51a2bc443eda4c5394e51521527fb6d264cd"

PR = "r0"

inherit rubygems
