SUMMARY = "url_safe_base64 - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "url_safe_base64"
HOMEPAGE = "http://rubygems.org/gems/url_safe_base64"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=fdd9b3c60a4438d2598af8c6fe350e7c"


SRC_URI[md5sum] = "f989e4c9d83cb0e800766b5e0e5f60e8"
SRC_URI[sha256sum] = "ff2bb6fb63fc5fa34dbab2c2f9199e0b8edf76de6c77e30a3595f07a95a7faf1"

PR = "r0"

inherit rubygems
