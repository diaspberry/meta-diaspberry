SUMMARY = "rb-fsevent - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rb-fsevent"
HOMEPAGE = "http://rubygems.org/gems/rb-fsevent"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=0f54ca712fa5d09964ad633d7ab46d36"


SRC_URI[md5sum] = "9a35b97527d1fe8b164344bd28968c9d"
SRC_URI[sha256sum] = "9b744c190144ce481500d7f23936512b5f25437b8c2def2d69933fdb1f7593f6"

PR = "r0"

inherit rubygems
