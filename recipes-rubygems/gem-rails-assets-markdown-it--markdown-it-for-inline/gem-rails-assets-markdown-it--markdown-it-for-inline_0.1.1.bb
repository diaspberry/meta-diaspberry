SUMMARY = "rails-assets-markdown-it--markdown-it-for-inline - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-markdown-it--markdown-it-for-inline"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-markdown-it--markdown-it-for-inline"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "9bed15a74e3b8ae7c51cd54a490a6536"
SRC_URI[sha256sum] = "540e094854142fa7c9872ea3461cfafcb2bb0c82f037b2f8c84d357bbad8f63b"

PR = "r0"

inherit rubygems
