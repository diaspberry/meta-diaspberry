SUMMARY = "railties - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "railties"
HOMEPAGE = "http://rubygems.org/gems/railties"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://lib/rails/generators/rails/plugin/templates/MIT-LICENSE;md5=76fadc47cf623a3659f524f75c6b0f6e"


SRC_URI[md5sum] = "4240092ec17b85ad8eea44a15c2ca7de"
SRC_URI[sha256sum] = "04e71a240bb21cce68aa1eec22304178e28a55c53f3168e9c1fb7f622c3b3f13"

PR = "r0"

inherit rubygems
