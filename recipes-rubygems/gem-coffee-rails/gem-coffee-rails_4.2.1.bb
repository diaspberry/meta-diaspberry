SUMMARY = "coffee-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "coffee-rails"
HOMEPAGE = "http://rubygems.org/gems/coffee-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=637f3db170371b6c2764fa5df64a31af"


SRC_URI[md5sum] = "7d3527a2abedc349bef63f4e3863b926"
SRC_URI[sha256sum] = "9173409e75d6b805749685a1466065cedd0fd6cdffebdeeb060610a500c40825"

PR = "r0"

inherit rubygems
