SUMMARY = "logging-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "logging-rails"
HOMEPAGE = "http://rubygems.org/gems/logging-rails"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "8ff7d2890db4c87b969c06c89f963db0"
SRC_URI[sha256sum] = "f85d5dd03cba4abd61244b37e6f895eda07cffcb61b9416a94867b6123ff8beb"

PR = "r0"

inherit rubygems
