SUMMARY = "fog-atmos - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-atmos"
HOMEPAGE = "http://rubygems.org/gems/fog-atmos"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=2d4a9ed9eb6dcb3ff099212762f2d73c"


SRC_URI[md5sum] = "ad877b0023fb2a8ac9625621e27d4648"
SRC_URI[sha256sum] = "89211f5ac26240ece0a67a197d12e95a0c76fdd7731c48a07e26f99fb87d5da9"

PR = "r0"

inherit rubygems
