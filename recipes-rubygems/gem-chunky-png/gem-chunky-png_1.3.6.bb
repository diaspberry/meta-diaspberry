SUMMARY = "chunky_png - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "chunky_png"
HOMEPAGE = "http://rubygems.org/gems/chunky_png"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6f1502f5990c2315487c1fabbbab544a"


SRC_URI[md5sum] = "a8d0c6d5f9d64f16c0a5eac482ee2fee"
SRC_URI[sha256sum] = "378143eb3fefd8ccc579ad8462fb15621607ab12b6bcccc6cff9ae4623092c6b"

PR = "r0"

inherit rubygems
