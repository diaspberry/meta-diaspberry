SUMMARY = "memoizable - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "memoizable"
HOMEPAGE = "http://rubygems.org/gems/memoizable"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=a731fea6f6e333338e99eb43c8c92311"


SRC_URI[md5sum] = "e289b0714e203d838a97c0f27ea934e4"
SRC_URI[sha256sum] = "acf4d2280fea019318e61cfc5e69077dcb3c2126817ee596ffd76d0ddf5e826c"

PR = "r0"

inherit rubygems
