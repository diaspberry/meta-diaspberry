SUMMARY = "method_source - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "method_source"
HOMEPAGE = "http://rubygems.org/gems/method_source"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7d1a6fbb73f604e1e716380490938bd4"


SRC_URI[md5sum] = "106c9cae069647807ba1c795b5b9334c"
SRC_URI[sha256sum] = "c2e9d0f4ebefd6b37efe38fe2964337b1d315fe198cad850681fd2da0027b1bc"

PR = "r0"

inherit rubygems
