SUMMARY = "powerpack - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "powerpack"
HOMEPAGE = "http://rubygems.org/gems/powerpack"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=39fcfe2463086aec3da3832a965c0686"


SRC_URI[md5sum] = "07857130e7468bc491c4b78de025a48a"
SRC_URI[sha256sum] = "83a81d0406f1628adc61b579689dc4509b30409a00fa4ca8f47ff212a91bd6ba"

PR = "r0"

inherit rubygems
