SUMMARY = "mime-types - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "mime-types"
HOMEPAGE = "http://rubygems.org/gems/mime-types"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "d81cae43778c88988ee8b3cedc03bc84"
SRC_URI[sha256sum] = "75949321c3f55e6618d0596016059841c26168342ec1ee4e641053bb66fa0701"

PR = "r0"

inherit rubygems
