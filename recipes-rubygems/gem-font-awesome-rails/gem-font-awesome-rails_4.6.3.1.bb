SUMMARY = "font-awesome-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "font-awesome-rails"
HOMEPAGE = "http://rubygems.org/gems/font-awesome-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3abf38decc031f54a69d793faff64627"


SRC_URI[md5sum] = "dce3d24031eaba746c47e9e374c0af15"
SRC_URI[sha256sum] = "ab6deebb17292ad073e2184e777bba2c022f2e28ba637a876d801de38d92bee1"

PR = "r0"

inherit rubygems
