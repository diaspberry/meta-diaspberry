SUMMARY = "eslintrb - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "eslintrb"
HOMEPAGE = "http://rubygems.org/gems/eslintrb"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d1440cf59290d2e9fc74d726fff96745"


SRC_URI[md5sum] = "4c14d2b696fa6d251d86759200878bb1"
SRC_URI[sha256sum] = "7d72dc3ac22858561d6edc19e39d83a8a0b030b6d47fe6bf1984da7bf4d2a94f"

PR = "r0"

inherit rubygems
