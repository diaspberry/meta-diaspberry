SUMMARY = "timecop - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "timecop"
HOMEPAGE = "http://rubygems.org/gems/timecop"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dbfb27b07afe594bd4e81167c5a58523"


SRC_URI[md5sum] = "1683f631691c700458da5c7b03024a79"
SRC_URI[sha256sum] = "bdce943521113e0b9ed2a6136e1c7396fa413ec7100814f2fe5bc1ee319f8b6f"

PR = "r0"

inherit rubygems
