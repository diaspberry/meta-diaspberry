SUMMARY = "useragent - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "useragent"
HOMEPAGE = "http://rubygems.org/gems/useragent"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=52832be286aca6e68583e43867c851fc"


SRC_URI[md5sum] = "c9267fc396ed4536c11a3abe61ef5ee0"
SRC_URI[sha256sum] = "18e23793f52862597576757bb61e9ecae329a50a6826c4190e1386edb1646984"

PR = "r0"

inherit rubygems
