SUMMARY = "twitter-text - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "twitter-text"
HOMEPAGE = "http://rubygems.org/gems/twitter-text"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=bc195d2436adc354f73372abdee78f6d"


SRC_URI[md5sum] = "d3ca0a4be9ce6dcbe3f6b8ec6af353dd"
SRC_URI[sha256sum] = "8c60d5be2dcfe19bb97d2f2549296cf5d4f52199de85ea7bb66e1196193cd294"

PR = "r0"

inherit rubygems
