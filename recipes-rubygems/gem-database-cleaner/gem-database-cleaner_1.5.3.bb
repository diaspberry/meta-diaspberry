SUMMARY = "database_cleaner - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "database_cleaner"
HOMEPAGE = "http://rubygems.org/gems/database_cleaner"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c8fd540d15f44f3cb6b121cc908d6e6d"


SRC_URI[md5sum] = "9193c97d6521ac0dfa50aaead4cefd05"
SRC_URI[sha256sum] = "5272375116e84a510da22c0321707aa48540bd1ce13843e59a954efb71fda63b"

PR = "r0"

inherit rubygems
