SUMMARY = "cucumber - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "cucumber"
HOMEPAGE = "http://rubygems.org/gems/cucumber"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=adebb0bb5b7a0d599e29bf13f59d758c"


SRC_URI[md5sum] = "89a1aa7e8e61a39703c92555689a8d4b"
SRC_URI[sha256sum] = "307e87c24e250d015c1d9990a7d79f7bdd9b239aa25681fd861fe491541892cc"

PR = "r0"

inherit rubygems
