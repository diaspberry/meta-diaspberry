SUMMARY = "json-jwt - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "json-jwt"
HOMEPAGE = "http://rubygems.org/gems/json-jwt"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=313632713b5a258eb5c887c49679d182"


SRC_URI[md5sum] = "503ee4bf2e5c7ed2ccc79d77e959426f"
SRC_URI[sha256sum] = "65ae3408dabcce12c24adefd45bdadc1fa58bd47e594e2615888470c8741fd15"

PR = "r0"

inherit rubygems
