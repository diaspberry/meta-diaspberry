SUMMARY = "compass - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "compass"
HOMEPAGE = "http://rubygems.org/gems/compass"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.markdown;md5=c1ba949f36b590566b9c4dd050aace96"


SRC_URI[md5sum] = "81e40f07164ccede8d95e44c79e44d7f"
SRC_URI[sha256sum] = "4c7884dc5349d59011fd6c5736a0404008d5609235037741feac9c8ff840d151"

PR = "r0"

inherit rubygems
