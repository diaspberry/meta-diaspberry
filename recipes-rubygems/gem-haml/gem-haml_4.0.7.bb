SUMMARY = "haml - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "haml"
HOMEPAGE = "http://rubygems.org/gems/haml"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=b0debb542a54637fa7caac9f1ca9b4a1"


SRC_URI[md5sum] = "54301683936cdf3678f5c513dab3871c"
SRC_URI[sha256sum] = "3754d0f7c21cf261a30b207a94524211293b921492fab58c89d1ede7e7933f57"

PR = "r0"

inherit rubygems
