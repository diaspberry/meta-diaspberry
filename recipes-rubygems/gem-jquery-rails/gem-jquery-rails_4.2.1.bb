SUMMARY = "jquery-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "jquery-rails"
HOMEPAGE = "http://rubygems.org/gems/jquery-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=dbb9221003034a4e944125d86e51555d"


SRC_URI[md5sum] = "853763e7a53edf2269cf7f16c8f019ad"
SRC_URI[sha256sum] = "3366f122a06c9b75d70b450aa4d23a226ecf78ac23377c0ca658c8b37bf4385f"

PR = "r0"

inherit rubygems
