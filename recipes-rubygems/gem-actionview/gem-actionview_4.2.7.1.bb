SUMMARY = "actionview - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "actionview"
HOMEPAGE = "http://rubygems.org/gems/actionview"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=c1a401c5778f1549ecfe3452a26d6c19"


SRC_URI[md5sum] = "9302758fc19c80b73787ee23c09a0356"
SRC_URI[sha256sum] = "0ccc4160fc8bc6f3f0db0d2c313ce747cd4c0921f540035d3a3ce3456de9a286"

PR = "r0"

inherit rubygems
