SUMMARY = "domain_name - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "domain_name"
HOMEPAGE = "http://rubygems.org/gems/domain_name"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=4c68eae14a38247dafecbdde79a46358"


SRC_URI[md5sum] = "61a41357f87aee3ef7e9906ab2e3d65f"
SRC_URI[sha256sum] = "afb018732f1d0b322b213413868cd21011dba62fd77b38ceba2e7a9ee67690b9"

PR = "r0"

inherit rubygems
