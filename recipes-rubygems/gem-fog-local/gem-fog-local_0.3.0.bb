SUMMARY = "fog-local - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-local"
HOMEPAGE = "http://rubygems.org/gems/fog-local"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=abbd839ed9d30325e7c8c6ce8a2e8a86"


SRC_URI[md5sum] = "9db818a90efd616b9cf5a6319b4da1cd"
SRC_URI[sha256sum] = "6ce84d964804a1e34fcc9c62973ecb080d196581658044a643780027f0a0a608"

PR = "r0"

inherit rubygems
