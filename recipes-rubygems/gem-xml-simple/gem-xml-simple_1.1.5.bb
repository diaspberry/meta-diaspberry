SUMMARY = "xml-simple - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "xml-simple"
HOMEPAGE = "http://rubygems.org/gems/xml-simple"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "be57835053eed1385923181619dd5411"
SRC_URI[sha256sum] = "88c33d33ec4e28f11d8479bd89331eabaa651fff5effe9d92d3dbaa11abd9876"

PR = "r0"

inherit rubygems
