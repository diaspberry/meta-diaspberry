SUMMARY = "celluloid-supervision - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "celluloid-supervision"
HOMEPAGE = "http://rubygems.org/gems/celluloid-supervision"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c593826d90d9bf33eae341a7a63e7107"


SRC_URI[md5sum] = "b7fca71cc5520070ac70cbefd1294b9c"
SRC_URI[sha256sum] = "fc6fc4840ecaf5080a703c75b3eda0cde7e28d81c6435d4b05ba569dc37b81ac"

PR = "r0"

inherit rubygems
