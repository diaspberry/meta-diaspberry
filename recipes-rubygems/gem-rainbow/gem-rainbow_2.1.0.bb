SUMMARY = "rainbow - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rainbow"
HOMEPAGE = "http://rubygems.org/gems/rainbow"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d8b3dd1cdfc682803de86f82b443bcd3"


SRC_URI[md5sum] = "0f5af1b9002d34627b309727d4cd9786"
SRC_URI[sha256sum] = "00b8f4ce73855d41bae7a41da31f13cee1843e8af7f22cba5cd86da676649186"

PR = "r0"

inherit rubygems
