SUMMARY = "rails-assets-jasmine-ajax - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-jasmine-ajax"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-jasmine-ajax"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "bf2fe666df5e7bca703a624f25b56838"
SRC_URI[sha256sum] = "1981448a0761d3a60488bc725cb93615f3ab1ef60e3af986cfb5c50be9b4e4c4"

PR = "r0"

inherit rubygems
