SUMMARY = "test_after_commit - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "test_after_commit"
HOMEPAGE = "http://rubygems.org/gems/test_after_commit"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=e1a30563d2c6315dbce95853b6a863a2"


SRC_URI[md5sum] = "c0647ec39adc2cdbf431260b969e5b65"
SRC_URI[sha256sum] = "82797655d3b6d18724ad5170dcca621c4d8efd40f5339783d21409dc01f81769"

PR = "r0"

inherit rubygems
