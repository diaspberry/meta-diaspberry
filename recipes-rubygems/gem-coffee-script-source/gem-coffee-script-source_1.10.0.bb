SUMMARY = "coffee-script-source - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "coffee-script-source"
HOMEPAGE = "http://rubygems.org/gems/coffee-script-source"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "25937acc32595f91345e5e7e1e2eeec0"
SRC_URI[sha256sum] = "e0e341d3717e0bc72c9e0d7113bed29ee8449723493ac8de5d83ce9cd3788ecc"

PR = "r0"

inherit rubygems
