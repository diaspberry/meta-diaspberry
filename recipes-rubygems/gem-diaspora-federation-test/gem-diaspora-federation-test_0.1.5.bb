SUMMARY = "diaspora_federation-test - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "diaspora_federation-test"
HOMEPAGE = "http://rubygems.org/gems/diaspora_federation-test"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "34acaed8ea6567c5c46d782ad1e56109"
SRC_URI[sha256sum] = "24cdd9c785086cd40450102af1083f4753e5adca9edab5e2d403a396252259bc"

PR = "r0"

inherit rubygems
