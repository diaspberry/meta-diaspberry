SUMMARY = "diaspora-prosody-config - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "diaspora-prosody-config"
HOMEPAGE = "http://rubygems.org/gems/diaspora-prosody-config"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d32239bcb673463ab874e80d47fae504"


SRC_URI[md5sum] = "18a9ee75080d8efaa630305695638712"
SRC_URI[sha256sum] = "970a3af5bf216df66ff4dd0e9f94c30b3625b306719bcc65c04c1627b18ce6a4"

PR = "r0"

inherit rubygems
