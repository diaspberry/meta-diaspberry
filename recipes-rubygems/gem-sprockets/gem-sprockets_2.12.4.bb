SUMMARY = "sprockets - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sprockets"
HOMEPAGE = "http://rubygems.org/gems/sprockets"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1c4c534da4d716e99e102becaddf7810"


SRC_URI[md5sum] = "9080a9153090c7f63c6dbb366d043565"
SRC_URI[sha256sum] = "e3bec4259a08ac4fe7c465554b54f25f85648f708c71ff20e1477c3f90410195"

PR = "r0"

inherit rubygems
