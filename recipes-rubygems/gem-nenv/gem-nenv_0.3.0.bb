SUMMARY = "nenv - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "nenv"
HOMEPAGE = "http://rubygems.org/gems/nenv"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=68439ee872b0b899d495cce831de3a36"


SRC_URI[md5sum] = "5a32cf94057c33f2d0fdbeaf75e79638"
SRC_URI[sha256sum] = "d9de6d8fb7072228463bf61843159419c969edb34b3cef51832b516ae7972765"

PR = "r0"

inherit rubygems
