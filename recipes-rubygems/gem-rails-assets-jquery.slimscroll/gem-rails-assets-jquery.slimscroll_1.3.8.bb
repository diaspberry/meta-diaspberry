SUMMARY = "rails-assets-jquery.slimscroll - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-jquery.slimscroll"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-jquery.slimscroll"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "c59b9591b4bfee929b5f351774a48f77"
SRC_URI[sha256sum] = "2825696d8eaf0130a49e79e86c8e28453bdaea52086d70a4943bf89e45abd5e7"

PR = "r0"

inherit rubygems
