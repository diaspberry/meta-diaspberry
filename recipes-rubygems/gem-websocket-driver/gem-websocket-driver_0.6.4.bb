SUMMARY = "websocket-driver - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "websocket-driver"
HOMEPAGE = "http://rubygems.org/gems/websocket-driver"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "25a96773ea56d01b7140cd4e12f8bc23"
SRC_URI[sha256sum] = "1e6aba563d385ce23eb9b9bcaefdd50829e1cf97606b24598f7bfa5e89c067d4"

PR = "r0"

inherit rubygems
