SUMMARY = "actionmailer - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "actionmailer"
HOMEPAGE = "http://rubygems.org/gems/actionmailer"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=c1a401c5778f1549ecfe3452a26d6c19"


SRC_URI[md5sum] = "43a8bfdbb818f18786fe23d76f69d13a"
SRC_URI[sha256sum] = "c30280bb13c187e768e575384f526ae3e75276df373d864f3f55e61ab4be8153"

PR = "r0"

inherit rubygems
