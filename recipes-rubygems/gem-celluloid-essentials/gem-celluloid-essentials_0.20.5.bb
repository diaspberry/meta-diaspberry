SUMMARY = "celluloid-essentials - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "celluloid-essentials"
HOMEPAGE = "http://rubygems.org/gems/celluloid-essentials"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=c593826d90d9bf33eae341a7a63e7107"


SRC_URI[md5sum] = "d4c5e9464872f846980003cd70c63006"
SRC_URI[sha256sum] = "3388206d134eaf2ec262f537bbdefb9e855956039888c0f901b2493ece1d97d0"

PR = "r0"

inherit rubygems
