SUMMARY = "ast - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "ast"
HOMEPAGE = "http://rubygems.org/gems/ast"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.MIT;md5=b46ff44655f29020fc7542adda3ad781"


SRC_URI[md5sum] = "e53bedabdc51f7aa10284c8af38bc917"
SRC_URI[sha256sum] = "15d97cf7f3430351a8663f2c5fb7591fb29f700fa28576c46c53b992e912e85e"

PR = "r0"

inherit rubygems
