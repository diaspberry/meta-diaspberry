SUMMARY = "jwt - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "jwt"
HOMEPAGE = "http://rubygems.org/gems/jwt"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b7c5ddc412bf0298cd997114a6c994c5"


SRC_URI[md5sum] = "e6783331e3570ce987db67b2623a1b02"
SRC_URI[sha256sum] = "51a851050fbfadf04e647011df5580212dd1a46892b0bc3ebcc05f58c9a2b468"

PR = "r0"

inherit rubygems
