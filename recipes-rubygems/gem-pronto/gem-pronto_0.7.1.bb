SUMMARY = "pronto - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "pronto"
HOMEPAGE = "http://rubygems.org/gems/pronto"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b0be4887c19ae74609f7ff9ca57ebb7c"


SRC_URI[md5sum] = "444d83f4e56df1665b4d9ceaf0fd26d6"
SRC_URI[sha256sum] = "f0e1342291b976c0842fcfd7c3538d7e4924de54b8e90b62aa8f188e9aabc10c"

PR = "r0"

inherit rubygems
