SUMMARY = "faraday - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "faraday"
HOMEPAGE = "http://rubygems.org/gems/faraday"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=568a12cd704a1a8cffdea31644c67d1a"


SRC_URI[md5sum] = "bb307e793b227c41e89e0f2c72d7c140"
SRC_URI[sha256sum] = "0662e5caa257c256cff4b073deef5c73e3469d3ed0b8d6e9a05e6861efc4f4ce"

PR = "r0"

inherit rubygems
