SUMMARY = "js-routes - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "js-routes"
HOMEPAGE = "http://rubygems.org/gems/js-routes"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=fb65cbb537f2b027b54021b08f03b2bc"


SRC_URI[md5sum] = "8dd73919fcead6db61158774d7f23406"
SRC_URI[sha256sum] = "eec09b1ee0f6f2214e7b37ee4e89cd99f7fa49536dc5ec1bdb1b617d9c865598"

PR = "r0"

inherit rubygems
