SUMMARY = "secure_headers - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "secure_headers"
HOMEPAGE = "http://rubygems.org/gems/secure_headers"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a178c10e634583bbd65df760d1978919"


SRC_URI[md5sum] = "b99ce55f2a6f6e7f962977f5a148cb40"
SRC_URI[sha256sum] = "c16d252385cb0786069ab5795df01a7fd68f802125c9dd5ad987a1bc8fb47999"

PR = "r0"

inherit rubygems
