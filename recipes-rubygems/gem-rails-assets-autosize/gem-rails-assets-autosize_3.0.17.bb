SUMMARY = "rails-assets-autosize - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-autosize"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-autosize"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "575fcdc413ae5dea422bd7eb2b6ef74e"
SRC_URI[sha256sum] = "50c8683374a9aa319fc3c1fd06bca40361cf59afe22e5ff563bc2925a87cda03"

PR = "r0"

inherit rubygems
