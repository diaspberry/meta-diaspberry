SUMMARY = "jasmine-core - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "jasmine-core"
HOMEPAGE = "http://rubygems.org/gems/jasmine-core"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "bb748e930d6b9188b562a5e08cb5a3c9"
SRC_URI[sha256sum] = "bb35a68042185123c1b2dd1f5f3ee27dd4b7a631154a7c0f11434632f9a20ed5"

PR = "r0"

inherit rubygems
