SUMMARY = "devise_lastseenable - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "devise_lastseenable"
HOMEPAGE = "http://rubygems.org/gems/devise_lastseenable"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=4be6d5f767372c69474d3277025fc223"


SRC_URI[md5sum] = "8d036e2bcb3b86bb2a2c0a0890c2f98d"
SRC_URI[sha256sum] = "1ef5bca96b8d81b59acca318db49e58351e427d409815ce9610e4189c78103c1"

PR = "r0"

inherit rubygems
