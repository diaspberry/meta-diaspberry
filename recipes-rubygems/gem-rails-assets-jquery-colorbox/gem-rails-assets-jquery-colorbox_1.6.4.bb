SUMMARY = "rails-assets-jquery-colorbox - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-jquery-colorbox"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-jquery-colorbox"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "b1170cc5df7561dbfc5a3558922c4738"
SRC_URI[sha256sum] = "57d7ba29596b5c3033fce828e226e61114ad713450029db2b33c6ef7431e9aa7"

PR = "r0"

inherit rubygems
