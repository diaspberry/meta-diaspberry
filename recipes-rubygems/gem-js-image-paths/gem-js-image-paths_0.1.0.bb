SUMMARY = "js_image_paths - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "js_image_paths"
HOMEPAGE = "http://rubygems.org/gems/js_image_paths"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=2311349604ce8f00d52149d45a99f60e"


SRC_URI[md5sum] = "8c081d381b75228538fbc862254b62be"
SRC_URI[sha256sum] = "f6cea96e9d4be67e16b9e3e00374e7754dc5253fff61af68d926dd8a6f0adfee"

PR = "r0"

inherit rubygems
