SUMMARY = "mysql2 - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "mysql2"
HOMEPAGE = "http://rubygems.org/gems/mysql2"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7dbd3a9f471247a243db5b62fe091587"


SRC_URI[md5sum] = "6663933bb99ba23958e9e7be7a6846fc"
SRC_URI[sha256sum] = "2adf72de58581ddb17abe952f5c7843ee0caf3455ed20c82f9c41583ce3aa3ec"

PR = "r0"

inherit rubygems
