SUMMARY = "string-direction - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "string-direction"
HOMEPAGE = "http://rubygems.org/gems/string-direction"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COPYING.txt;md5=d32239bcb673463ab874e80d47fae504"


SRC_URI[md5sum] = "464098b0c857b4f2f0ae668e6ff25eb6"
SRC_URI[sha256sum] = "7b5b0270c1ce998b58109fa99fa28f5013c899d07fcb073eb6c0b5450d4d30b3"

PR = "r0"

inherit rubygems
