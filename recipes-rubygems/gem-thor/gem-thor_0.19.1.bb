SUMMARY = "thor - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "thor"
HOMEPAGE = "http://rubygems.org/gems/thor"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=690cce21f4e069148a52834e1ecf352e"


SRC_URI[md5sum] = "d775969c49fec36377b918725aa33019"
SRC_URI[sha256sum] = "9ff834f031b5550c743bb8a3139317fefdae9cdebd02d60de376658f427fe522"

PR = "r0"

inherit rubygems
