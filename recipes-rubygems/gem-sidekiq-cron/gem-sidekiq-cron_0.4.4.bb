SUMMARY = "sidekiq-cron - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sidekiq-cron"
HOMEPAGE = "http://rubygems.org/gems/sidekiq-cron"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=1c864a405b3a79ce126c059ed7592288"


SRC_URI[md5sum] = "e9bdce1c9a72ba67d5eae6b7be57fc37"
SRC_URI[sha256sum] = "aacdff12e1f4486abe34bdae835a476d6c75b812b6c3dbd87d1440e7214051af"

PR = "r0"

inherit rubygems
