SUMMARY = "rails-assets-jquery - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-jquery"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-jquery"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "081cecf44b1af0832bfabe5b2a5ee9b0"
SRC_URI[sha256sum] = "b46d3f1b304dcbfcfda9c7b3ea085b7f172432e357ea5a4403e94f3e6db490b5"

PR = "r0"

inherit rubygems
