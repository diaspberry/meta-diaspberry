SUMMARY = "responders - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "responders"
HOMEPAGE = "http://rubygems.org/gems/responders"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=d381c176e2f94d6c2aba81c60d38d826"


SRC_URI[md5sum] = "7f19b9c05f087e20221869beb8b89d59"
SRC_URI[sha256sum] = "5130d7eb75e92170237963cac4fce6d1560de36aa1de2ad88eba9a95f520039a"

PR = "r0"

inherit rubygems
