SUMMARY = "httparty - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "httparty"
HOMEPAGE = "http://rubygems.org/gems/httparty"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=51cdec3ab44d6e2a10c625e5fa026945"


SRC_URI[md5sum] = "1591f0d993874ad6cae342b9ebf67e04"
SRC_URI[sha256sum] = "22c3f4d2681aeb083d4703405799fbc96453ff0d38c3ae3c1e5070dcccdb2f31"

PR = "r0"

inherit rubygems
