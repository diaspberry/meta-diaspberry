SUMMARY = "turbo_dev_assets - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "turbo_dev_assets"
HOMEPAGE = "http://rubygems.org/gems/turbo_dev_assets"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=93d5644e38979bd7129648703267a304"


SRC_URI[md5sum] = "3f44e93103df19e23b441735044a3659"
SRC_URI[sha256sum] = "fdc6cffa0bc3d8efe051e83c6f36f30889738cee30987616924e421def3bd723"

PR = "r0"

inherit rubygems
