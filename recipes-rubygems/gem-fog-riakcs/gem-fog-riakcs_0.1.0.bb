SUMMARY = "fog-riakcs - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-riakcs"
HOMEPAGE = "http://rubygems.org/gems/fog-riakcs"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=c49f43d89d92c142681b0052066c9d57"


SRC_URI[md5sum] = "8f6634e23a9ab1405e4cd699fc086b53"
SRC_URI[sha256sum] = "b5431e8863829177fb79102e67ddb6dbdc5462c52ad45733774f0d3f1b617dd9"

PR = "r0"

inherit rubygems
