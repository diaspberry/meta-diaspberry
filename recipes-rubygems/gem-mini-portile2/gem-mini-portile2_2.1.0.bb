SUMMARY = "mini_portile2 - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "mini_portile2"
HOMEPAGE = "http://rubygems.org/gems/mini_portile2"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ca91f53befc541b9880a8502e7d2699d"


SRC_URI[md5sum] = "d771975a58cef82daa6b0ee03522293f"
SRC_URI[sha256sum] = "0b0e83fe0fc190640a93c48cef0c8e1f1f40f77840d82c160fefc1b07a5345f8"

PR = "r0"

inherit rubygems
