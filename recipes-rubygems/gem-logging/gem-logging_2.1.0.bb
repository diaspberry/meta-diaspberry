SUMMARY = "logging - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "logging"
HOMEPAGE = "http://rubygems.org/gems/logging"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "cf493abf5b77fce3882d78b484cb7224"
SRC_URI[sha256sum] = "34a0c16415a587c434e1f0d7ac5de9805d33de6e2636d5edc5c0765a7603f3a9"

PR = "r0"

inherit rubygems
