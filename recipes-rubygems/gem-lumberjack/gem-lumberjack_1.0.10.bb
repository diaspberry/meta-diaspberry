SUMMARY = "lumberjack - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "lumberjack"
HOMEPAGE = "http://rubygems.org/gems/lumberjack"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT_LICENSE;md5=fe4c5608a11dd7413c2f85d5ab7e8b30"


SRC_URI[md5sum] = "18c3ee579c8616d25cff44c9f6105c58"
SRC_URI[sha256sum] = "64eb76f7898436256c359dc8ee54924d8fe24f35159ff553e0a9243c90449e46"

PR = "r0"

inherit rubygems
