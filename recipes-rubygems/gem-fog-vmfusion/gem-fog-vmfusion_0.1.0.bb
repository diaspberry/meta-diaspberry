SUMMARY = "fog-vmfusion - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-vmfusion"
HOMEPAGE = "http://rubygems.org/gems/fog-vmfusion"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=294bc83e3cef4204aa34aa63ed004810"


SRC_URI[md5sum] = "75437c393005ec5336041df22c597080"
SRC_URI[sha256sum] = "c4769c038f80774936a629c8712f3d843a94d412d064fc6f826176ead304143c"

PR = "r0"

inherit rubygems
