SUMMARY = "sigar - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sigar"
HOMEPAGE = "http://rubygems.org/gems/sigar"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8f7bb094c7232b058c7e9f2e431f389c"


SRC_URI[md5sum] = "041e12f78275250e5c2ae59445595efe"
SRC_URI[sha256sum] = "250a3bd8170f51bf377aa666d44ae08a321c655a2c63c14dffa41fe478308d88"

PR = "r0"

inherit rubygems
