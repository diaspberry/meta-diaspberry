SUMMARY = "activejob - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "activejob"
HOMEPAGE = "http://rubygems.org/gems/activejob"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=763e26a8a016e3055ac742a14c44db37"


SRC_URI[md5sum] = "ea93f7b4d52df1511c392f614593764a"
SRC_URI[sha256sum] = "5f3db0e8e190e3dafd1ceeb0f0832dfe47e60b5742c4d08d3bb26e8b1a2f5047"

PR = "r0"

inherit rubygems
