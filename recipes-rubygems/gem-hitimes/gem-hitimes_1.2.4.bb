SUMMARY = "hitimes - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "hitimes"
HOMEPAGE = "http://rubygems.org/gems/hitimes"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=18123decc0ab87e5f898408f153eb90b"


SRC_URI[md5sum] = "3efd6d42337007d39f5bafe6d464dbdc"
SRC_URI[sha256sum] = "9f026a767ccd2c50654d5772de3f3fc57aeba72ee4a7e481e8afdc7d24749ea8"

PR = "r0"

inherit rubygems
