SUMMARY = "pronto-eslint - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "pronto-eslint"
HOMEPAGE = "http://rubygems.org/gems/pronto-eslint"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b0be4887c19ae74609f7ff9ca57ebb7c"


SRC_URI[md5sum] = "c64d533a3f066825b566ea227af797d1"
SRC_URI[sha256sum] = "591dfc08d8a2d27d6acbd20f1bfdc158be4d849a20dc5e4e0ebdf68528b46fc2"

PR = "r0"

inherit rubygems
