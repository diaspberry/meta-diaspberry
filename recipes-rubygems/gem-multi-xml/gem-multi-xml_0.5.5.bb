SUMMARY = "multi_xml - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "multi_xml"
HOMEPAGE = "http://rubygems.org/gems/multi_xml"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=7f40f4b8aae9d03f3d38d028fc5115a1"


SRC_URI[md5sum] = "afecb8240f7a14a9183d79f8df5bfa3f"
SRC_URI[sha256sum] = "08936dc294586ee1d178217cce577febe26315d7880e01e4f8e97cf2753b1945"

PR = "r0"

inherit rubygems
