SUMMARY = "remotipart - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "remotipart"
HOMEPAGE = "http://rubygems.org/gems/remotipart"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6d01df24fe754c620270d7c746a33ac2"


SRC_URI[md5sum] = "bcb279dbaaca68ccfbd3dd717e178c52"
SRC_URI[sha256sum] = "615584b70c4aeee5633a2df9995955c703bbb6a3d1611ea5e00f33ac7d035266"

PR = "r0"

inherit rubygems
