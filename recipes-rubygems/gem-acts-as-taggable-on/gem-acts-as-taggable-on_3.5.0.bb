SUMMARY = "acts-as-taggable-on - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "acts-as-taggable-on"
HOMEPAGE = "http://rubygems.org/gems/acts-as-taggable-on"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=ff8ce59cf9a2df232c8bd031c17c974d"


SRC_URI[md5sum] = "eb84a9e2587629df11c35e669fd28e34"
SRC_URI[sha256sum] = "27dfb17d01ed056c5d28b54142d356bac55953ce66259fa0fad28d4b1bfae02f"

PR = "r0"

inherit rubygems
