SUMMARY = "rack-piwik - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-piwik"
HOMEPAGE = "http://rubygems.org/gems/rack-piwik"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=787a86012a8849953f6ddd662f895548"


SRC_URI[md5sum] = "bc8436f40686df54da367af94d1ff71c"
SRC_URI[sha256sum] = "1f85916c7e34e697df795a7b567e1d51ec2043b70cb478e94806e2ab26cb5d65"

PR = "r0"

inherit rubygems
