SUMMARY = "cliver - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "cliver"
HOMEPAGE = "http://rubygems.org/gems/cliver"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=fc4f8c2bb5ef24befeb730549759c524"


SRC_URI[md5sum] = "64b519a314384c03e15ff1257c09208b"
SRC_URI[sha256sum] = "8775445218c612bb57f50c392c4906a1ab5cca067eab093bde3cc77d6426ce24"

PR = "r0"

inherit rubygems
