SUMMARY = "ffi - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "ffi"
HOMEPAGE = "http://rubygems.org/gems/ffi"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COPYING;md5=0b4e3af2fd54eb00a94b967e6b927818"


SRC_URI[md5sum] = "ad08c78dc7a2345d027b17f85223108a"
SRC_URI[sha256sum] = "d77d1ccb9cab032fff7ea2b7db1a895a2a2129a72c529e890f6b838c7bcd6cda"

PR = "r0"

inherit rubygems
