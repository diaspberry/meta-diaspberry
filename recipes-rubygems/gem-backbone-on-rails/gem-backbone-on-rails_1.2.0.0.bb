SUMMARY = "backbone-on-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "backbone-on-rails"
HOMEPAGE = "http://rubygems.org/gems/backbone-on-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b7a577962dbb72ea944c68668b4bc64"


SRC_URI[md5sum] = "f1eabe7ce3d4a753f980fc98f668ee89"
SRC_URI[sha256sum] = "2bbd770057d91435b6df7b629e57b9f0504b139a98ee3787586dad502bb123d8"

PR = "r0"

inherit rubygems
