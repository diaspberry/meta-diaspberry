SUMMARY = "open_graph_reader - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "open_graph_reader"
HOMEPAGE = "http://rubygems.org/gems/open_graph_reader"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=37e1bdbc16bc48394afef9826c84d865"


SRC_URI[md5sum] = "de488be962a5a4b3e74e7d16868db5cd"
SRC_URI[sha256sum] = "b78ed839328cc1b5d764a0ef7b546e2c792691945807cf6a45f39031d3b1b76e"

PR = "r0"

inherit rubygems
