SUMMARY = "omniauth-facebook - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "omniauth-facebook"
HOMEPAGE = "http://rubygems.org/gems/omniauth-facebook"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "623dc6344f0c10b4e8312b1b6ec66aff"
SRC_URI[sha256sum] = "05ae3565c8fdb38df8dab04eb8ca854ea6c18e81591d3e6598ce101293a2f20f"

PR = "r0"

inherit rubygems
