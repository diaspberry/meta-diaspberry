SUMMARY = "typhoeus - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "typhoeus"
HOMEPAGE = "http://rubygems.org/gems/typhoeus"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f682dfe96a40016f62f81f9ccf0eab7c"


SRC_URI[md5sum] = "48f0f371735497974c3c91452109ab6e"
SRC_URI[sha256sum] = "7cd206c6e446c5f3f17da7962a3dc656058e254ead7af907da817e7ddaa4bba9"

PR = "r0"

inherit rubygems
