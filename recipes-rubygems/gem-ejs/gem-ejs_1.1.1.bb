SUMMARY = "ejs - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "ejs"
HOMEPAGE = "http://rubygems.org/gems/ejs"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fd65d504a5aea756bba2e5b724c76245"


SRC_URI[md5sum] = "cd097940846a2bde793deaf9f99ea8c2"
SRC_URI[sha256sum] = "8746ed10be7e8d305b6be8eb1589fcd3d193f3706cc617ec26de297c86fe07bc"

PR = "r0"

inherit rubygems
