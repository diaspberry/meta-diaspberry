SUMMARY = "redis-namespace - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "redis-namespace"
HOMEPAGE = "http://rubygems.org/gems/redis-namespace"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fbbd010314b3f1554733123ecde55a52"


SRC_URI[md5sum] = "fa018c37656ffe772faeecfa6627bf4e"
SRC_URI[sha256sum] = "45bc24a12fda90feb6b916e649198053522bc399e6249d66ffb83bfba77be866"

PR = "r0"

inherit rubygems
