SUMMARY = "fog-radosgw - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-radosgw"
HOMEPAGE = "http://rubygems.org/gems/fog-radosgw"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=6f32a4e48c2ca71808b2ee9d7fc87e83"


SRC_URI[md5sum] = "898bf2d99d0b518940144e0ec10bc502"
SRC_URI[sha256sum] = "267baecdf66272293b9fc1c8178d30d1e8a35f4855ff217d8e1397ebd17e545b"

PR = "r0"

inherit rubygems
