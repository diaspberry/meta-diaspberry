SUMMARY = "compass-core - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "compass-core"
HOMEPAGE = "http://rubygems.org/gems/compass-core"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=aee65e2d0ffecd09add0ae382f21163e"


SRC_URI[md5sum] = "561bc7f5597bfef532eae016e4510cd8"
SRC_URI[sha256sum] = "6ac8bb4cabb5bf80d1a7febbacfd35c1aa83e91a7a511637668dffda38be5a79"

PR = "r0"

inherit rubygems
