SUMMARY = "celluloid-pool - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "celluloid-pool"
HOMEPAGE = "http://rubygems.org/gems/celluloid-pool"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=a18b3f6c9af6cf998f94ded2af018ef8"


SRC_URI[md5sum] = "c4142b89c3d8a6c3afe82e3dcb305017"
SRC_URI[sha256sum] = "ac9453bfb063582913712131aab5f0c026e7c82d0e2e4531b4ab242a2329d9ad"

PR = "r0"

inherit rubygems
