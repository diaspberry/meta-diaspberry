SUMMARY = "hashdiff - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "hashdiff"
HOMEPAGE = "http://rubygems.org/gems/hashdiff"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6c10cc38b516520cc860825a29852508"


SRC_URI[md5sum] = "7c23fb77bb7137d6ecce0e7737a78edc"
SRC_URI[sha256sum] = "04844d6f841e96ead0f1453597a92045cae5abb1c74fc0fcf790dc8fb27a06e4"

PR = "r0"

inherit rubygems
