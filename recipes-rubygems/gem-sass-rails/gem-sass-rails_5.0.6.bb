SUMMARY = "sass-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sass-rails"
HOMEPAGE = "http://rubygems.org/gems/sass-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=bbe542225491edcada3bf1f744b4ea54"


SRC_URI[md5sum] = "3604634b0b2f0001ae224882d18e0a3c"
SRC_URI[sha256sum] = "8bb5d9ed4e83c7e1ad2b518daf13a266b995c40a5ac74bc2673633b420105146"

PR = "r0"

inherit rubygems
