SUMMARY = "rspec-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rspec-rails"
HOMEPAGE = "http://rubygems.org/gems/rspec-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=21b565acdbfc9f257f6a44d119ddb8e9"


SRC_URI[md5sum] = "d67b21141f355e36f7783d386cda8209"
SRC_URI[sha256sum] = "554ebe1122e3070297b2b761a34a13727d37c06814037f04adcdc71bf591ca71"

PR = "r0"

inherit rubygems
