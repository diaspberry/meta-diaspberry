SUMMARY = "notiffany - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "notiffany"
HOMEPAGE = "http://rubygems.org/gems/notiffany"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=68439ee872b0b899d495cce831de3a36"


SRC_URI[md5sum] = "671cc57b014f3c5153b4191a8faa83fa"
SRC_URI[sha256sum] = "dda20d5fa14df72a9857d594927677c5b1eed69d9d8eba7e6a0dd05894430375"

PR = "r0"

inherit rubygems
