SUMMARY = "fog-terremark - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-terremark"
HOMEPAGE = "http://rubygems.org/gems/fog-terremark"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=8ef1c98fb9ef9a53182211665af6bbf8"


SRC_URI[md5sum] = "430fc50d4946e6cf3a89aad687d7739c"
SRC_URI[sha256sum] = "8e8ec8592daab86c965e6a5454f0846e8deacff2bcd249ed8c40de2b139c8e06"

PR = "r0"

inherit rubygems
