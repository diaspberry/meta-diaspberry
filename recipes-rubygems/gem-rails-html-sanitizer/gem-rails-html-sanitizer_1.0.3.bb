SUMMARY = "rails-html-sanitizer - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-html-sanitizer"
HOMEPAGE = "http://rubygems.org/gems/rails-html-sanitizer"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "d13c644238baf23fb79d39c820c51a11"
SRC_URI[sha256sum] = "a7da8eb4ce2e673ba909d36a94a9e06f196e88a92e76d01dfee3803d0d6a0e8d"

PR = "r0"

inherit rubygems
