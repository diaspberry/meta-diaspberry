SUMMARY = "autoprefixer-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "autoprefixer-rails"
HOMEPAGE = "http://rubygems.org/gems/autoprefixer-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e0ef868fdaaba6859dcbab082c20439b"


SRC_URI[md5sum] = "c58c5f54202991cf0cd78dec58185b94"
SRC_URI[sha256sum] = "718f9b9606df85e875d65e97de9bb60264957e62a1fabe8d47f3f8822c90932b"

PR = "r0"

inherit rubygems
