SUMMARY = "redis - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "redis"
HOMEPAGE = "http://rubygems.org/gems/redis"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2822f759e526422a3d69ad8b3b134497"


SRC_URI[md5sum] = "8c85f28e3782c91630f93efb53c4258c"
SRC_URI[sha256sum] = "97bb3fd676c1781d9912bcbea2831a56962bb3d627555a0c641b4386811c19d9"

PR = "r0"

inherit rubygems
