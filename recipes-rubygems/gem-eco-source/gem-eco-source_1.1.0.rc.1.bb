SUMMARY = "eco-source - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "eco-source"
HOMEPAGE = "http://rubygems.org/gems/eco-source"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "723c9891f5459273ea9d1b5945fdad9e"
SRC_URI[sha256sum] = "412d4f5209e4ed86ec8692e0a2869a8d87d5cb0289c420db2cbc1aa6d4ce9db1"

PR = "r0"

inherit rubygems
