SUMMARY = "naught - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "naught"
HOMEPAGE = "http://rubygems.org/gems/naught"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ab89649a1a6e0ed33a2d9478a7094e1e"


SRC_URI[md5sum] = "db9a8cf018cc78377c6395664c08e2f0"
SRC_URI[sha256sum] = "4f4f6b44e52237ffca56977ccee1cafa93e95434062974e9b580adf7cbe892f3"

PR = "r0"

inherit rubygems
