SUMMARY = "rubocop - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rubocop"
HOMEPAGE = "http://rubygems.org/gems/rubocop"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=677198307e54dc11d182a5fe6f5d94b5"


SRC_URI[md5sum] = "4b10b96c72cf9319fd669433e666584c"
SRC_URI[sha256sum] = "ddca83f353721240eb3563c2d9b5fb7e9928845058a6a49f23aab79d25ca83f6"

PR = "r0"

inherit rubygems
