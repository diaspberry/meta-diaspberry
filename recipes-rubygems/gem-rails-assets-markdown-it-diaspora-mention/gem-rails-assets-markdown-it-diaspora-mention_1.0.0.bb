SUMMARY = "rails-assets-markdown-it-diaspora-mention - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-markdown-it-diaspora-mention"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-markdown-it-diaspora-mention"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "c55e3555ad84b36c63fa57b029af03da"
SRC_URI[sha256sum] = "e3c6bc5493377bb2bbca991ca9034892245389b58a420f8f90d80c1b30b16686"

PR = "r0"

inherit rubygems
