SUMMARY = "rails-timeago - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-timeago"
HOMEPAGE = "http://rubygems.org/gems/rails-timeago"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=cc673f8ba3ede79a5293b45dab6e4b7a"


SRC_URI[md5sum] = "18eae613539dde93738eb250581a6d4e"
SRC_URI[sha256sum] = "7d33882f48f87139ad7b6790628d9b9ebd1592c9eea94451c644765691f3efd0"

PR = "r0"

inherit rubygems
