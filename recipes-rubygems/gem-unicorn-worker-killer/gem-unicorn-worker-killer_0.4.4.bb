SUMMARY = "unicorn-worker-killer - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "unicorn-worker-killer"
HOMEPAGE = "http://rubygems.org/gems/unicorn-worker-killer"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4255ff0d5ccff0e6f58e6ae98ccdadba"


SRC_URI[md5sum] = "5d3ab7c9378bb4a3ed50ca0253c6eab2"
SRC_URI[sha256sum] = "6abfc15229c12b42f13242a17e292ec838b27af5c846d9d521fd2addf8ed2d67"

PR = "r0"

inherit rubygems
