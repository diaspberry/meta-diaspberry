SUMMARY = "webmock - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "webmock"
HOMEPAGE = "http://rubygems.org/gems/webmock"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=613632d6860fad1a3606569621c55673"


SRC_URI[md5sum] = "869bd2348073f65daa29e2f8e37671da"
SRC_URI[sha256sum] = "e4ccb85d1483409533daf01f08b6af198cf8603fb2a71106207acb084f96cb58"

PR = "r0"

inherit rubygems
