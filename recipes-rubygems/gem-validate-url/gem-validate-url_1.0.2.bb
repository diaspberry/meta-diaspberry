SUMMARY = "validate_url - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "validate_url"
HOMEPAGE = "http://rubygems.org/gems/validate_url"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=0991cc24fce58a05b6c593e69e0699f9"


SRC_URI[md5sum] = "a898dadb1c7410db27d5cfae7dfb486a"
SRC_URI[sha256sum] = "100b37584934babe3ee446f26fb27368f992f873bba040d7adf1c786207bc4b5"

PR = "r0"

inherit rubygems
