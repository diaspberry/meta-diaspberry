SUMMARY = "arel - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "arel"
HOMEPAGE = "http://rubygems.org/gems/arel"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE.txt;md5=6bc713ef12984659b8fd62fa7e46df17"


SRC_URI[md5sum] = "8ab245d9d0af1c2e63aabb5675c8d174"
SRC_URI[sha256sum] = "f3676eafca9987cb5fe263df1edf2538bf6dafc712b30e17be3543a9680547a8"

PR = "r0"

inherit rubygems
