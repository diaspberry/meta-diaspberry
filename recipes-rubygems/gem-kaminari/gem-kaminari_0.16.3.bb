SUMMARY = "kaminari - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "kaminari"
HOMEPAGE = "http://rubygems.org/gems/kaminari"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=a448ca79b95d639c4ee6ad859f3de92a"


SRC_URI[md5sum] = "8dcf5e07d58e63e40f7efd713405334c"
SRC_URI[sha256sum] = "c75072e46983598423564906ba72e9d66bc8c52e393f63a7d89450addf1c7d93"

PR = "r0"

inherit rubygems
