SUMMARY = "fog-google - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-google"
HOMEPAGE = "http://rubygems.org/gems/fog-google"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=0d99eb7fb945c4591bbb8c4ec17da700"


SRC_URI[md5sum] = "02413559ad5730ba61c2e88a5ab9694b"
SRC_URI[sha256sum] = "433a983f57d594b0d729a4f735516d3cb4a02dd3f9630e1801f0727cb9ae9b7c"

PR = "r0"

inherit rubygems
