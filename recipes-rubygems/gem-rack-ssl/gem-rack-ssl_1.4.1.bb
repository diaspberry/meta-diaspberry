SUMMARY = "rack-ssl - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-ssl"
HOMEPAGE = "http://rubygems.org/gems/rack-ssl"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=00981e2ce829a2b19c5a88eda36e7f0e"


SRC_URI[md5sum] = "3938e1e66436e69054584204d020bb9e"
SRC_URI[sha256sum] = "f7f9d359c13d563fd0fe3e4eced0b357d8ba0502c837839f7520502f27ee4130"

PR = "r0"

inherit rubygems
