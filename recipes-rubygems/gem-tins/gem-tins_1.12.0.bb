SUMMARY = "tins - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "tins"
HOMEPAGE = "http://rubygems.org/gems/tins"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COPYING;md5=700e8b6f1de60d3c72bcfa37fa5fd080"


SRC_URI[md5sum] = "319a6b93d1276fa605ae77132ecfbb71"
SRC_URI[sha256sum] = "f1d874386ab15d32cd9ade46f6dac5a1e7964025d639c908f9a4af15a32dca79"

PR = "r0"

inherit rubygems
