SUMMARY = "active_model_serializers - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "active_model_serializers"
HOMEPAGE = "http://rubygems.org/gems/active_model_serializers"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=5355153cab5dcfa53e9051f95ed58cd5"


SRC_URI[md5sum] = "431aa08b14ef06b640f3c9b41a4e43fb"
SRC_URI[sha256sum] = "279deb7f4bdd841322046318549e4240831850022df9b4ab2bda9044e05a4e10"

PR = "r0"

inherit rubygems
