SUMMARY = "eco - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "eco"
HOMEPAGE = "http://rubygems.org/gems/eco"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fd65d504a5aea756bba2e5b724c76245"


SRC_URI[md5sum] = "401e4b31b74f9fc1b6d5c33b5ae02426"
SRC_URI[sha256sum] = "2037de66bce1b4edcef3a7fd4368e11872a232545d5530ceec1abc79cfe25126"

PR = "r0"

inherit rubygems
