SUMMARY = "http-cookie - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "http-cookie"
HOMEPAGE = "http://rubygems.org/gems/http-cookie"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f217a5829e26ed04a05e5ba14eaf2128"


SRC_URI[md5sum] = "70529d56540a162f52ce361a389a0307"
SRC_URI[sha256sum] = "bcc1b18b5bc3e9302542c9c7f68f1ac0c3100a65dd2831786172e8676773e233"

PR = "r0"

inherit rubygems
