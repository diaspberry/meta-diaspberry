SUMMARY = "entypo-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "entypo-rails"
HOMEPAGE = "http://rubygems.org/gems/entypo-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE_ENTYPO;md5=70b2a8ca3b28d1e2c0c62226b31adf69"


SRC_URI[md5sum] = "4e62420a543a3c2005d9e933baa1447d"
SRC_URI[sha256sum] = "504a2ac4e90617f34007c67985b2a5c842847692c119954efe1a5876f464b98c"

PR = "r0"

inherit rubygems
