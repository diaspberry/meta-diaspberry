SUMMARY = "diff-lcs - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "diff-lcs"
HOMEPAGE = "http://rubygems.org/gems/diff-lcs"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://docs/COPYING.txt;md5=b234ee4d69f5fce4486a80fdaf4a4263"


SRC_URI[md5sum] = "7172cb271324fa944d9fbea5fe1f7344"
SRC_URI[sha256sum] = "a1d3dde665292317a883d319066792e3f0e6a24cade4bc4cc47605d27664c9ed"

PR = "r0"

inherit rubygems
