SUMMARY = "jquery-ui-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "jquery-ui-rails"
HOMEPAGE = "http://rubygems.org/gems/jquery-ui-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://License.txt;md5=c7ccedf6c682b63714bab53415a15f0d"


SRC_URI[md5sum] = "3169379faa3770b4392be0ca057e30f7"
SRC_URI[sha256sum] = "e7f499fdc6f305bc08e5860fef65cfe7ac307f3f9c9e339868f2ca45767edebd"

PR = "r0"

inherit rubygems
