SUMMARY = "fog-serverlove - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-serverlove"
HOMEPAGE = "http://rubygems.org/gems/fog-serverlove"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=3b5a0bebab5a46fb5393225a55374b89"


SRC_URI[md5sum] = "86ddbeb322378ccf94638ea42756c774"
SRC_URI[sha256sum] = "913da54ba43cd9b4e6955ac822fba11d64afbf35b100af572e82e7e73fafaf43"

PR = "r0"

inherit rubygems
