SUMMARY = "mail - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "mail"
HOMEPAGE = "http://rubygems.org/gems/mail"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=7dfe718341485fe56390fefb1f7c6c9d"


SRC_URI[md5sum] = "3e43923308949f33f7281e88c92dc101"
SRC_URI[sha256sum] = "77d6a70c45d435dde688f841a9aa955571b8f3c624966812282b290bbcc33b31"

PR = "r0"

inherit rubygems
