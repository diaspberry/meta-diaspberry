SUMMARY = "rails-assets-favico.js - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-favico.js"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-favico.js"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "9fbcdea9d51500926d2de436bc81f660"
SRC_URI[sha256sum] = "7b957ca24d1830454d055b6479f57e165c807f38bbc0445c569be22a296cd6a7"

PR = "r0"

inherit rubygems
