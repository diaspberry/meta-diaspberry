SUMMARY = "pronto-scss - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "pronto-scss"
HOMEPAGE = "http://rubygems.org/gems/pronto-scss"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b0be4887c19ae74609f7ff9ca57ebb7c"


SRC_URI[md5sum] = "30a1777a8c35d951c1ad8e687f686d47"
SRC_URI[sha256sum] = "4c416a9b9f4f76c9491ee73b683c741d2c06b70fe892cd8d56f28c9e8adddfcc"

PR = "r0"

inherit rubygems
