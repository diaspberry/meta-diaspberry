SUMMARY = "rails-assets-bootstrap - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-bootstrap"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-bootstrap"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "8688c8cd837f1a6730ace5e8db808f84"
SRC_URI[sha256sum] = "bbf483e0f2bda151dbffb0280ae2c9594f7f088ec180852b7c95613142089174"

PR = "r0"

inherit rubygems
