SUMMARY = "docile - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "docile"
HOMEPAGE = "http://rubygems.org/gems/docile"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=cb75b7b5bb07152a4268d5d4908e90ce"


SRC_URI[md5sum] = "5e5baf4ed5c4b1090914ccd30f2da075"
SRC_URI[sha256sum] = "5d3ee40b3a6567fe460601f3f4a3e199a98de37434ebfa242d751d0c79181255"

PR = "r0"

inherit rubygems
