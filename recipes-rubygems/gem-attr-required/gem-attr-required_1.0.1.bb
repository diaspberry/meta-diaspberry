SUMMARY = "attr_required - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "attr_required"
HOMEPAGE = "http://rubygems.org/gems/attr_required"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fbcec52df98e0ac23b32722ba7888e6b"


SRC_URI[md5sum] = "58962d14c2c60e76eeb15ad48e7fa63d"
SRC_URI[sha256sum] = "024e10393bd30901e1adf6769bd756b873a5ef7da60f86f8f11066116b5742bc"

PR = "r0"

inherit rubygems
