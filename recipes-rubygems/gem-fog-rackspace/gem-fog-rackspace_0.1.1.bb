SUMMARY = "fog-rackspace - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-rackspace"
HOMEPAGE = "http://rubygems.org/gems/fog-rackspace"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=5f620753247e2f1322d87d662eaa5575"


SRC_URI[md5sum] = "1147516b4521e8ff71e5f6b979110964"
SRC_URI[sha256sum] = "4a8c7a2432dd32321958c869f3b1b8190cf4eac292024e6ea267bc6040a44b78"

PR = "r0"

inherit rubygems
