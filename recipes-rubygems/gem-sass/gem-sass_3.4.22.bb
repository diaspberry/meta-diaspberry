SUMMARY = "sass - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sass"
HOMEPAGE = "http://rubygems.org/gems/sass"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=decaeea30c54b6fb62192923c10e4871"


SRC_URI[md5sum] = "857f0bc182b254271e3f03654ed5d2ab"
SRC_URI[sha256sum] = "9e7bad9b3854e1913a6d30eb3bae69eca8dd61e55c63a92a78e14d67c4367236"

PR = "r0"

inherit rubygems
