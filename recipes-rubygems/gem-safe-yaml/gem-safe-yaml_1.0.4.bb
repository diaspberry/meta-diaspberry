SUMMARY = "safe_yaml - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "safe_yaml"
HOMEPAGE = "http://rubygems.org/gems/safe_yaml"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=87342e90f6d5e1c4c246b64ec59c982b"


SRC_URI[md5sum] = "a92204c1caa87816c0d1c72bd8419c90"
SRC_URI[sha256sum] = "248193992ef1730a0c9ec579999ef2256a2b3a32a9bd9d708a1e12544a489ec2"

PR = "r0"

inherit rubygems
