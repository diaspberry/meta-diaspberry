SUMMARY = "faraday_middleware - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "faraday_middleware"
HOMEPAGE = "http://rubygems.org/gems/faraday_middleware"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=a59d0c4589d25cc5037028f3465378d6"


SRC_URI[md5sum] = "229fb5d80723a23cf1e2abe965152e07"
SRC_URI[sha256sum] = "b0e4d2ed22b0229f65b128b277b93662f9f41a7a2b7cefb02911f9df8d50b15b"

PR = "r0"

inherit rubygems
