SUMMARY = "unf_ext - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "unf_ext"
HOMEPAGE = "http://rubygems.org/gems/unf_ext"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6ca1fa10e57f6b051236c822f2f8767f"


SRC_URI[md5sum] = "88cf9fe1fa51c12ddc4645e4546c3492"
SRC_URI[sha256sum] = "e8fa13d09880f8d06d30a86f929a38ba0af6abe61272927a49e6796aee1aa111"

PR = "r0"

inherit rubygems
