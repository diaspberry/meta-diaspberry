SUMMARY = "celluloid-fsm - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "celluloid-fsm"
HOMEPAGE = "http://rubygems.org/gems/celluloid-fsm"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=c593826d90d9bf33eae341a7a63e7107"


SRC_URI[md5sum] = "6e6483d19e07baf6b5042c3dc98650a8"
SRC_URI[sha256sum] = "6c47aa938d7d8edb674594c21453e8b7d11a26a5a66543ee67f32e45a089b7de"

PR = "r0"

inherit rubygems
