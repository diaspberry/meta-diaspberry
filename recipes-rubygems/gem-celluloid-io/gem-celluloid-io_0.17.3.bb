SUMMARY = "celluloid-io - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "celluloid-io"
HOMEPAGE = "http://rubygems.org/gems/celluloid-io"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=7afdd83b06c76dc372a16f1dc4c5bb53"


SRC_URI[md5sum] = "a9cae39dd935048957ce53623b5b443b"
SRC_URI[sha256sum] = "248c9a3f91612eaea6b1625f4742e92e93d24129ce1d7eb8ee6c277894bc2cbb"

PR = "r0"

inherit rubygems
