SUMMARY = "webfinger - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "webfinger"
HOMEPAGE = "http://rubygems.org/gems/webfinger"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=64d2d6b335d963d34f89c03994c6a782"


SRC_URI[md5sum] = "48d595ceb1514279a6a1bff975b46d06"
SRC_URI[sha256sum] = "91c1a0a447820ce02afc095ff18e4e8d830e30372e731e61f00cbefee9c23fe5"

PR = "r0"

inherit rubygems
