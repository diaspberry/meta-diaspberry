SUMMARY = "http_parser.rb - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "http_parser.rb"
HOMEPAGE = "http://rubygems.org/gems/http_parser.rb"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE-MIT;md5=157efc3766c6d07d3d857ebbab43351a"


SRC_URI[md5sum] = "1c9d471b7fd78d5857d6d12fe016278e"
SRC_URI[sha256sum] = "f11d0aec50ef26a7d1f991e627ac88acdb5979282aeba7a5c3be6ce0636ed196"

PR = "r0"

inherit rubygems
