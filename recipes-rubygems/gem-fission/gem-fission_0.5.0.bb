SUMMARY = "fission - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fission"
HOMEPAGE = "http://rubygems.org/gems/fission"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dfb27f384bde45498f52913b965087ef"


SRC_URI[md5sum] = "0064fdd7777d605249a617a6af6a6562"
SRC_URI[sha256sum] = "f0cb26612fdb64a446ec29c9be644c32e8a3a95056d855d91d19e51c64b8f526"

PR = "r0"

inherit rubygems
