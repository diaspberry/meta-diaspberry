SUMMARY = "openid_connect - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "openid_connect"
HOMEPAGE = "http://rubygems.org/gems/openid_connect"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=87f7cb5eef9b64cdba1e106406a94e81"


SRC_URI[md5sum] = "bcc76cd16f5dcb63db6ed1acb7449c77"
SRC_URI[sha256sum] = "abb1c900a05e5c6e94f8caefeb185ce804106c2b36ed62bb72d7af7f5f896c53"

PR = "r0"

inherit rubygems
