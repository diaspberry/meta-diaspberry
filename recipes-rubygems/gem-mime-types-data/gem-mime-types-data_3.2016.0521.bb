SUMMARY = "mime-types-data - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "mime-types-data"
HOMEPAGE = "http://rubygems.org/gems/mime-types-data"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "09fa6e5e6f366a01e5622b52a34701d8"
SRC_URI[sha256sum] = "7542bccff06d70c4ad94d1cf10b7dac6bd89958356e5d0d7f6447168c819be12"

PR = "r0"

inherit rubygems
