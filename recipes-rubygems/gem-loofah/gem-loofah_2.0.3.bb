SUMMARY = "loofah - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "loofah"
HOMEPAGE = "http://rubygems.org/gems/loofah"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE.txt;md5=b7217a9d17d69aa78e9b9d040799a850"


SRC_URI[md5sum] = "601a17a439a009d9efd61d19943ded10"
SRC_URI[sha256sum] = "48c76e74f25229e0f492c2aaf770253fe44b162a0d18c2de1c59831b44d13781"

PR = "r0"

inherit rubygems
