SUMMARY = "cucumber-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "cucumber-rails"
HOMEPAGE = "http://rubygems.org/gems/cucumber-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=29d146fc5cf1a0f2a5ae71e493969b41"


SRC_URI[md5sum] = "1d4113aa67384d54bef14b16fdc5758e"
SRC_URI[sha256sum] = "db127640c43fd1ccdda0d60a66af534235e9ce4504e1e20666ad9d6e5b316f7a"

PR = "r0"

inherit rubygems
