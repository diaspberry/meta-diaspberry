SUMMARY = "coderay - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "coderay"
HOMEPAGE = "http://rubygems.org/gems/coderay"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "6f60cedad4f128b38bd8eaf40490f328"
SRC_URI[sha256sum] = "79a42eba4cbe2b056ba253eb02d1a7aec74ca951e54f33098830641e8748dff4"

PR = "r0"

inherit rubygems
