SUMMARY = "leaflet-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "leaflet-rails"
HOMEPAGE = "http://rubygems.org/gems/leaflet-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e2bc48ea739808c194334a51c7bd4600"


SRC_URI[md5sum] = "6129ecb8580f421040f4f702c14a8cc0"
SRC_URI[sha256sum] = "167f341d81509e9d6cf7776118cf5c51c261a7ec5514e1b6d9886d3e1d4582d8"

PR = "r0"

inherit rubygems
