SUMMARY = "CFPropertyList - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "CFPropertyList"
HOMEPAGE = "http://rubygems.org/gems/CFPropertyList"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4de6076c1bdff198c535fb0e3ace58a4"


SRC_URI[md5sum] = "970e83ca1e528d744807eb5a78a73e56"
SRC_URI[sha256sum] = "e2f1b93707dfa2ae8b136caacab6e5307747c2ec4f3337ba8a907c6486214b56"

PR = "r0"

inherit rubygems
