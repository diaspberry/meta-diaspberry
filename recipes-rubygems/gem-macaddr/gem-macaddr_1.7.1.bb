SUMMARY = "macaddr - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "macaddr"
HOMEPAGE = "http://rubygems.org/gems/macaddr"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=98e0cae50247eeba146f96333d51ed19"


SRC_URI[md5sum] = "aade5990769cbeee7a0df9390f3f7030"
SRC_URI[sha256sum] = "0b58a645b11de68388df8515a4e46dd047ffbcb49296546da50556b82b8a91b2"

PR = "r0"

inherit rubygems
