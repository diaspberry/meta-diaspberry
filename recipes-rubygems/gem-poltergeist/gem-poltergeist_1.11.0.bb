SUMMARY = "poltergeist - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "poltergeist"
HOMEPAGE = "http://rubygems.org/gems/poltergeist"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=29be86d6c4e5e743797f04643c075d2a"


SRC_URI[md5sum] = "95a1c06815692d829d0c5e98572c9936"
SRC_URI[sha256sum] = "d497f8813d99d4ba08b0d68817b911870219b3beb5c83ca3ee5fc10b217e1f25"

PR = "r0"

inherit rubygems
