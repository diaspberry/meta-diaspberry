SUMMARY = "rack-google-analytics - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-google-analytics"
HOMEPAGE = "http://rubygems.org/gems/rack-google-analytics"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1d2beb04bbfdcdcbe4ff7492cd5aa3e4"


SRC_URI[md5sum] = "51988e5617f7513102f2eec9458ec13f"
SRC_URI[sha256sum] = "72b3cfcce77cd7f3aecaf88cd1633cce980811f1b8489c22a4594ad8ca07fb26"

PR = "r0"

inherit rubygems
