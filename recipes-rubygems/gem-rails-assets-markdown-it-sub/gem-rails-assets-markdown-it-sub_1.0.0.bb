SUMMARY = "rails-assets-markdown-it-sub - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-markdown-it-sub"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-markdown-it-sub"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "c37bcc2248b1eece892e382e13005d66"
SRC_URI[sha256sum] = "333348dc9981c08a05ed671636c72327e9a931468fd823f4791b6eec8a8c1222"

PR = "r0"

inherit rubygems
