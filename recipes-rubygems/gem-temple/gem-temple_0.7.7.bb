SUMMARY = "temple - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "temple"
HOMEPAGE = "http://rubygems.org/gems/temple"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=80973c10a7b3aa4187edb50548c24cf1"


SRC_URI[md5sum] = "69ecf9198d4cb1658409140fae573d05"
SRC_URI[sha256sum] = "e63318989be2da09df121b447b234dedcbff87ef1641ee66254176315c0c8e76"

PR = "r0"

inherit rubygems
