SUMMARY = "asset_sync - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "asset_sync"
HOMEPAGE = "http://rubygems.org/gems/asset_sync"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "bc32e6831fd2a6d5235adf1aea080bbd"
SRC_URI[sha256sum] = "c49a696e7a5f1eb730f8d82d4becdfab401094113106b2b83d7a7f432adf857a"

PR = "r0"

inherit rubygems
