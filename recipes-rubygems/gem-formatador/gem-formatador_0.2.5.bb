SUMMARY = "formatador - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "formatador"
HOMEPAGE = "http://rubygems.org/gems/formatador"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=723586805a3f7d63d95bb84d8c415de6"


SRC_URI[md5sum] = "f2d7213efd6a327ec6c34262185f6e2e"
SRC_URI[sha256sum] = "80821869ddacb79e72870ff4bb1531efacd278c04f2df26bc6b4529ee13582bd"

PR = "r0"

inherit rubygems
