SUMMARY = "sinon-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sinon-rails"
HOMEPAGE = "http://rubygems.org/gems/sinon-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=70038c2be73bf2b0c2c72966a343a84f"


SRC_URI[md5sum] = "7ec3e8025b2d1ea212391041ab8d7dd1"
SRC_URI[sha256sum] = "ebbd39b67c402008eb7736f92f5e83db44d441a2987db092f0d36db4a049e9ac"

PR = "r0"

inherit rubygems
