SUMMARY = "fog-powerdns - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-powerdns"
HOMEPAGE = "http://rubygems.org/gems/fog-powerdns"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=131a1bd032537f103803f4a3e0bed1e3"


SRC_URI[md5sum] = "b2438a549381df5735de38050c0d8ff5"
SRC_URI[sha256sum] = "0742dafc5e272869ae8bc1562d9bb65f6a9bbc261fde81fe2364cce9f8dfea23"

PR = "r0"

inherit rubygems
