SUMMARY = "octokit - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "octokit"
HOMEPAGE = "http://rubygems.org/gems/octokit"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=7b1247f46e3156be0d8f01b0986c2562"


SRC_URI[md5sum] = "5f932f9deb37be6487bcf4b452c2e48d"
SRC_URI[sha256sum] = "d71ed1ec090ee60d3ae79095b15f4055f46361fcdad3f5f3c87b800f263b04c3"

PR = "r0"

inherit rubygems
