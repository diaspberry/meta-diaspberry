SUMMARY = "haml_lint - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "haml_lint"
HOMEPAGE = "http://rubygems.org/gems/haml_lint"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "601ccdd3f8f2ccdd8c09f351040c9aee"
SRC_URI[sha256sum] = "918b927da5d77955fd566d8c1462c28cd64551a295fa3618399c9a634d50126a"

PR = "r0"

inherit rubygems
