SUMMARY = "rails-assets-markdown-it-sup - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-markdown-it-sup"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-markdown-it-sup"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "053341b6ee5fe301a861da3b274358c4"
SRC_URI[sha256sum] = "2f565a8056b9fe4620b37a5cd787717bfbb95644b519ca79f4c0ffe3e7b6d69e"

PR = "r0"

inherit rubygems
