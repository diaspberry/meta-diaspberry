SUMMARY = "rails-deprecated_sanitizer - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-deprecated_sanitizer"
HOMEPAGE = "http://rubygems.org/gems/rails-deprecated_sanitizer"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "c11a2be49ab18f4ca9734cbea5738506"
SRC_URI[sha256sum] = "722d589fc83dea0ea49e816440bacc554383dc9a05c8aee5429cf7f621abbe63"

PR = "r0"

inherit rubygems
