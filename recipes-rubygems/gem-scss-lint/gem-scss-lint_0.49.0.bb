SUMMARY = "scss_lint - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "scss_lint"
HOMEPAGE = "http://rubygems.org/gems/scss_lint"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=36e52c1ac3b3a1598bbdeadd8f33f443"


SRC_URI[md5sum] = "580ba28e39d04a836180afdbdceea475"
SRC_URI[sha256sum] = "5b1a77b05fc1f55ab9f7c6de1ccd9bb78407917fe43d0cb6b82c0e44e4240bb4"

PR = "r0"

inherit rubygems
