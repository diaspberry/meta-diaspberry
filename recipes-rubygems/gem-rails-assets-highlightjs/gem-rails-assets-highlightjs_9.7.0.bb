SUMMARY = "rails-assets-highlightjs - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-highlightjs"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-highlightjs"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "58bb9d9ded8e6c69a1f54da819e4052f"
SRC_URI[sha256sum] = "759389c78f2a55485fac64907f94255847ed5d14b68053fa80dba73935072e1e"

PR = "r0"

inherit rubygems
