SUMMARY = "cucumber-core - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "cucumber-core"
HOMEPAGE = "http://rubygems.org/gems/cucumber-core"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8e12cae5e24944b264f94b23195102bf"


SRC_URI[md5sum] = "2bdcc78682764141b1b584b5be0b08a4"
SRC_URI[sha256sum] = "594a30969a33f03693915db7eaa2a137e45fed76d9ae19ed7b96a4bbb1764262"

PR = "r0"

inherit rubygems
