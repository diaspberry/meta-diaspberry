SUMMARY = "bcrypt - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "bcrypt"
HOMEPAGE = "http://rubygems.org/gems/bcrypt"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COPYING;md5=64bd8a0d3896c920e7ff8ca686d2fe13"


SRC_URI[md5sum] = "3048f1bd080b9e6cc856a22c84b8577b"
SRC_URI[sha256sum] = "a0fc22135205c851f46e8a661de8be242d54951cbd2c37a6fad5c8069b2645b4"

PR = "r3"

inherit rubygems
