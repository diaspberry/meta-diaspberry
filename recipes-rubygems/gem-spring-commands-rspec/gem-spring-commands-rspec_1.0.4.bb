SUMMARY = "spring-commands-rspec - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "spring-commands-rspec"
HOMEPAGE = "http://rubygems.org/gems/spring-commands-rspec"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=59a5909e63c947d33a53de609a08de46"


SRC_URI[md5sum] = "d1b093da4d323e6d21607fbc85b75da1"
SRC_URI[sha256sum] = "6202e54fa4767452e3641461a83347645af478bf45dddcca9737b43af0dd1a2c"

PR = "r0"

inherit rubygems
