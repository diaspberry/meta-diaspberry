SUMMARY = "fuubar - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fuubar"
HOMEPAGE = "http://rubygems.org/gems/fuubar"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=e8a88841eadf3c6c49cec814666ae1e7"


SRC_URI[md5sum] = "b6a84b44c8b547a6ffd2437f0f48587c"
SRC_URI[sha256sum] = "9b0263c4074f39c68b37f1e4e69a7d3cfc7523c41bea43601235daa723179b4a"

PR = "r0"

inherit rubygems
