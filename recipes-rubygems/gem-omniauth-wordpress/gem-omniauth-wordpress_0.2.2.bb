SUMMARY = "omniauth-wordpress - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "omniauth-wordpress"
HOMEPAGE = "http://rubygems.org/gems/omniauth-wordpress"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=08f5018357d8401ab47972762dca3edf"


SRC_URI[md5sum] = "fe348ca1c9ce9556f47fba7f07bcab4f"
SRC_URI[sha256sum] = "030c58e9ae802ed857ef9b3fb6799cfa17d0c244c643b31fddfeafcc3fe91f01"

PR = "r0"

inherit rubygems
