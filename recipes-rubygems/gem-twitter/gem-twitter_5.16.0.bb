SUMMARY = "twitter - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "twitter"
HOMEPAGE = "http://rubygems.org/gems/twitter"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=16d29ffcbd766cdc462fcd0e22156af3"


SRC_URI[md5sum] = "f6092b2dcaeb2a8248a39b8a1dfa364e"
SRC_URI[sha256sum] = "2e67efb529baf50ddb4adb3b04d641fa8fb3a67ad44ee24a4a1569012038a0ed"

PR = "r0"

inherit rubygems
