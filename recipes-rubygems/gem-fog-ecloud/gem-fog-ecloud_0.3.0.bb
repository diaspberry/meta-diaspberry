SUMMARY = "fog-ecloud - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-ecloud"
HOMEPAGE = "http://rubygems.org/gems/fog-ecloud"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=3f3a702bb4c56f7b8b6ae917847f081d"


SRC_URI[md5sum] = "2189b3a5ad652f31b2967b9ed36bf0ef"
SRC_URI[sha256sum] = "06c456b3729635860473a3917ac3f15ba708011419c9bb37e6bca7a624262ba3"

PR = "r0"

inherit rubygems
