SUMMARY = "get_process_mem - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "get_process_mem"
HOMEPAGE = "http://rubygems.org/gems/get_process_mem"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "516fd25d5811dd9a7af95eb7f80a92a6"
SRC_URI[sha256sum] = "bdb5453d11dc0322a50dfce97d95e9cf3b815a8e95ba04f8ea197ddc9a7dcd83"

PR = "r0"

inherit rubygems
