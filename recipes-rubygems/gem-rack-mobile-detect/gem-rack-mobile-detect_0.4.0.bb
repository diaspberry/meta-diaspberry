SUMMARY = "rack-mobile-detect - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-mobile-detect"
HOMEPAGE = "http://rubygems.org/gems/rack-mobile-detect"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=34d246c52f15f9a09932823a7ed699b6"


SRC_URI[md5sum] = "3b64abe3eef40b95d557b71afe07b260"
SRC_URI[sha256sum] = "45a1badfdb675056dfa892ad677493c4167e7cd7e59cea7d6877c2464da44f2d"

PR = "r0"

inherit rubygems
