SUMMARY = "omniauth-oauth - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "omniauth-oauth"
HOMEPAGE = "http://rubygems.org/gems/omniauth-oauth"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=cbecc5eadf80561d7101820f252c4c00"


SRC_URI[md5sum] = "d66be65b0a3b5d6c710b0597b11c3d6c"
SRC_URI[sha256sum] = "67808f891c2b6961090d7c3dc22f57c5e79795e099aed412607ec2e31799bbd8"

PR = "r0"

inherit rubygems
