SUMMARY = "hamlit - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "hamlit"
HOMEPAGE = "http://rubygems.org/gems/hamlit"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://benchmark/slim/LICENSE;md5=3f7b96efd00167bdd8040cc55a3e9aff"


SRC_URI[md5sum] = "ff2b2bb011b4bdd41b941f6ab4183d83"
SRC_URI[sha256sum] = "168acf4455f974867252e5c14e69bb6bb3a42c55ecabcecda0ab4465b27c81df"

PR = "r0"

inherit rubygems
