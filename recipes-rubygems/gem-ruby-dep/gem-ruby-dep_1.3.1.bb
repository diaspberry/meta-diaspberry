SUMMARY = "ruby_dep - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "ruby_dep"
HOMEPAGE = "http://rubygems.org/gems/ruby_dep"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=a45a3dea7f8c51a4245231a10e1c4124"


SRC_URI[md5sum] = "c62e3018f7b4c61c5124c7c314307a99"
SRC_URI[sha256sum] = "14814183f004eba3e3db9c9b534b65208294412ab99aa337e934a5f4bbfd186c"

PR = "r0"

inherit rubygems
