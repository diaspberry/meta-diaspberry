SUMMARY = "http - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "http"
HOMEPAGE = "http://rubygems.org/gems/http"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=9f4ebb92ffb0b41505efce0c23cea1c6"


SRC_URI[md5sum] = "72854c39c5924fad3c3e0cd37ad323ba"
SRC_URI[sha256sum] = "b4f45cf0dd09719e1ae9bee5e82c961ee81074e3800be432023150387a2fcf27"

PR = "r0"

inherit rubygems
