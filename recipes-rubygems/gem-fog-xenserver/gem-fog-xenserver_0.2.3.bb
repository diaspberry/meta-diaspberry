SUMMARY = "fog-xenserver - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-xenserver"
HOMEPAGE = "http://rubygems.org/gems/fog-xenserver"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=229860204ac1561810206c5816781040"


SRC_URI[md5sum] = "122836764b93954be4fb7c6fc4377420"
SRC_URI[sha256sum] = "60742ac7e215cd98c72177a289790a7e17101ed5e586f95a861c10445e811dcc"

PR = "r0"

inherit rubygems
