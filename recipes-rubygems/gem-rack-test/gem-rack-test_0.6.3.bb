SUMMARY = "rack-test - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-test"
HOMEPAGE = "http://rubygems.org/gems/rack-test"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE.txt;md5=b010b2c949f753e8e9ee5c14c0e97180"


SRC_URI[md5sum] = "c7db48faa3d1887198f7ce56726990e8"
SRC_URI[sha256sum] = "ff60b122e2940e32e94a2e4a61bceb8d9c99a97c1817ecc47e535522b02cdd40"

PR = "r0"

inherit rubygems
