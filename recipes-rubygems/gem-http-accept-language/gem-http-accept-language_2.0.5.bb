SUMMARY = "http_accept_language - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "http_accept_language"
HOMEPAGE = "http://rubygems.org/gems/http_accept_language"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "d7e6224ccc0589adfddad84fdc4d73ce"
SRC_URI[sha256sum] = "5b4713286a306d029efd2afd8ba57a7e4968c474d17b7aad770db5b0a3dae66d"

PR = "r0"

inherit rubygems
