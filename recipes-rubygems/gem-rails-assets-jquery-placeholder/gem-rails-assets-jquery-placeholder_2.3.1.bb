SUMMARY = "rails-assets-jquery-placeholder - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-jquery-placeholder"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-jquery-placeholder"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "1a6d15cbd4fc3c8d3fbe17b4f13518e9"
SRC_URI[sha256sum] = "11b29887a1b724ade5e7363eb612be9734c2b918e245511991f708f6957c2740"

PR = "r0"

inherit rubygems
