SUMMARY = "coffee-script - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "coffee-script"
HOMEPAGE = "http://rubygems.org/gems/coffee-script"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=00981e2ce829a2b19c5a88eda36e7f0e"


SRC_URI[md5sum] = "336e00bd13c629288ba7ee214c4d13cb"
SRC_URI[sha256sum] = "82fe281e11b93c8117b98c5ea8063e71741870f1c4fbb27177d7d6333dd38765"

PR = "r0"

inherit rubygems
