SUMMARY = "listen - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "listen"
HOMEPAGE = "http://rubygems.org/gems/listen"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=5cce4e14a2b69c74e9c91d66a93c7b65"


SRC_URI[md5sum] = "526af08cfe7d65d44a8680fd5d89d97e"
SRC_URI[sha256sum] = "bd9ab5f1615a7e491a2251c09f0fae9407ab3bd7650bdb517dda54ec6cae6507"

PR = "r0"

inherit rubygems
