SUMMARY = "addressable - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "addressable"
HOMEPAGE = "http://rubygems.org/gems/addressable"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f124bfaefacd4e1a4080065d403bc1d4"


SRC_URI[md5sum] = "2d340295a78606dcb68f93b7730e76d1"
SRC_URI[sha256sum] = "7abfff765571b0a73549c9a9d2f7e143979cd0c252f7fa4c81e7102a973ef656"

PR = "r0"

inherit rubygems
