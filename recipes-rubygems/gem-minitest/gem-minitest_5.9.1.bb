SUMMARY = "minitest - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "minitest"
HOMEPAGE = "http://rubygems.org/gems/minitest"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "29ac3a246a28492309d1a06c6116a698"
SRC_URI[sha256sum] = "78b5e553dd15bb12b3bd0b59c8b4fa7152a6134c51a3099c4eedd2489cb2000c"

PR = "r0"

inherit rubygems
