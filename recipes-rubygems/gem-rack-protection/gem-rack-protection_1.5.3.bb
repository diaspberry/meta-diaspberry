SUMMARY = "rack-protection - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-protection"
HOMEPAGE = "http://rubygems.org/gems/rack-protection"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://License;md5=800cdf7b61409ee28105360d3e1aa91c"


SRC_URI[md5sum] = "e09611d89bb40fb901c80b43c2a8c446"
SRC_URI[sha256sum] = "b9c08cb17b13c6672ef642cc4855b4c4ba8fcb1f66abc687f03cddf37f106b33"

PR = "r0"

inherit rubygems
