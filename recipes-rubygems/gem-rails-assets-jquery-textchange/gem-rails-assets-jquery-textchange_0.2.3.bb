SUMMARY = "rails-assets-jquery-textchange - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-jquery-textchange"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-jquery-textchange"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "8db91c73b413a0da8205cb34ae167318"
SRC_URI[sha256sum] = "b29196c57a6a5dc5d43a3933ecd00266d75c671a6314ff01dad216952c1b5c67"

PR = "r0"

inherit rubygems
