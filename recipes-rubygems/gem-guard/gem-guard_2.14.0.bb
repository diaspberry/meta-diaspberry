SUMMARY = "guard - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "guard"
HOMEPAGE = "http://rubygems.org/gems/guard"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5ea7f9373296858ef9c4b9619f35b2b6"


SRC_URI[md5sum] = "ae8c5ad804df2fad9f4f751cd2d6bef2"
SRC_URI[sha256sum] = "0e071764e3fb3c3658ec08e077ab3c9a3b21dbe1f0e62ad62554e4b1f6830dc6"

PR = "r0"

inherit rubygems
