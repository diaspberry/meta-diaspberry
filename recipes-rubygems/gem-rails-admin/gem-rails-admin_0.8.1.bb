SUMMARY = "rails_admin - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails_admin"
HOMEPAGE = "http://rubygems.org/gems/rails_admin"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=96d097ab772eb8774246268a39c49c94"


SRC_URI[md5sum] = "e09af07c7dece4fa7269f8527b45c735"
SRC_URI[sha256sum] = "eea4d4a5d6415417dc98d2f6edb8a5d7e80bb3d5a8d9e1647401581a7df0a1d2"

PR = "r0"

inherit rubygems
