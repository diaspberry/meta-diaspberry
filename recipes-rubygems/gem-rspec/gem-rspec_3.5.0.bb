SUMMARY = "rspec - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rspec"
HOMEPAGE = "http://rubygems.org/gems/rspec"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=3d68fc2cfabf7ef564c5e9d537c8da05"


SRC_URI[md5sum] = "d1040cb53a931b94674cf93568dc3413"
SRC_URI[sha256sum] = "dab06dc328931b0711943f074989ff45cfc3341e4c7cb6cd022ea50463ade399"

PR = "r0"

inherit rubygems
