SUMMARY = "celluloid - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "celluloid"
HOMEPAGE = "http://rubygems.org/gems/celluloid"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=d80e5939c6ef4720df47ed65c28478f6"


SRC_URI[md5sum] = "ad24f31cff4cd61b6f93abe346453a9c"
SRC_URI[sha256sum] = "afe25394c5954e3b14131389bb0550259deadaf37d90978b8399b6390f4e2282"

PR = "r0"

inherit rubygems
