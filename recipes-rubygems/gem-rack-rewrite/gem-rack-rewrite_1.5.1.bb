SUMMARY = "rack-rewrite - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-rewrite"
HOMEPAGE = "http://rubygems.org/gems/rack-rewrite"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3369a2dd60d6c6b924dac2d3bffa467a"


SRC_URI[md5sum] = "0803184b6679d0742f3e91df9c65d515"
SRC_URI[sha256sum] = "682079619b15e4a8084377ce12887b2d14cdafff6b23120db3dca4ddc2e13456"

PR = "r0"

inherit rubygems
