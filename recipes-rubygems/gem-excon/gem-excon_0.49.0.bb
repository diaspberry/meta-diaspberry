SUMMARY = "excon - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "excon"
HOMEPAGE = "http://rubygems.org/gems/excon"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=2eb478cb626b4f8aed90aa4a7851ae9d"


SRC_URI[md5sum] = "093ca8dc7476329a629e34dac1d577a1"
SRC_URI[sha256sum] = "1fb00ffeae85bb1d81ea0b61a5d88df8593cec1643a5f32e637d5148097bad4a"

PR = "r0"

inherit rubygems
