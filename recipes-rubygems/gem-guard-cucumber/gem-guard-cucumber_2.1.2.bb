SUMMARY = "guard-cucumber - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "guard-cucumber"
HOMEPAGE = "http://rubygems.org/gems/guard-cucumber"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=54b633c2ebed38d139327fa9239592a0"


SRC_URI[md5sum] = "aabd4bc4cea15ec1dec101719222fb8c"
SRC_URI[sha256sum] = "264f7a0489099a808fb79d0c7e9190002fd659bcc4ee2fe4a2b4dd7d1a01bece"

PR = "r0"

inherit rubygems
