SUMMARY = "fog-aliyun - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-aliyun"
HOMEPAGE = "http://rubygems.org/gems/fog-aliyun"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=802226b594bdc8ecd33925ebda330df5"


SRC_URI[md5sum] = "e641130758b94c2b105a02424ea5d92d"
SRC_URI[sha256sum] = "f2863abbff1cc12e32bbda383e1eafede8534e4cd634cb1e60ce4fdd347ae6c4"

PR = "r0"

inherit rubygems
