SUMMARY = "xpath - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "xpath"
HOMEPAGE = "http://rubygems.org/gems/xpath"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "ee492d351f9f2f462bd9921b94bc7435"
SRC_URI[sha256sum] = "9ca4a1cc88d9ab16c591468cce7b5d00ee06a8a76b841f8438970c7a44c86c12"

PR = "r0"

inherit rubygems
