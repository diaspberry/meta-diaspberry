SUMMARY = "rails-assets-markdown-it-hashtag - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-markdown-it-hashtag"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-markdown-it-hashtag"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "63ca6a0c0333de03c7ad94af127d2f35"
SRC_URI[sha256sum] = "b331117c4e048199da84bacfa703c7cc8708aa6f92d04cfea9d8cdd715772837"

PR = "r0"

inherit rubygems
