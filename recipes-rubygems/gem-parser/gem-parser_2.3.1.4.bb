SUMMARY = "parser - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "parser"
HOMEPAGE = "http://rubygems.org/gems/parser"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=c66fb0a7723eeead586d670198ad6a34"


SRC_URI[md5sum] = "38543d714b8ef67612f4cf497c796b74"
SRC_URI[sha256sum] = "a151d8a39ab06e05365c940209f745728f5d0b4388c669eb3cde04ef18ce2251"

PR = "r0"

inherit rubygems
