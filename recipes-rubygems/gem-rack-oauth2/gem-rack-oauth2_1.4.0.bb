SUMMARY = "rack-oauth2 - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-oauth2"
HOMEPAGE = "http://rubygems.org/gems/rack-oauth2"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fbcec52df98e0ac23b32722ba7888e6b"


SRC_URI[md5sum] = "856f1fd3b06afeaa4688d6bf5c4f0a38"
SRC_URI[sha256sum] = "dc700ce633735415f5541c75c739521421b9e42e7aba1a29508124427c9ceb16"

PR = "r0"

inherit rubygems
