SUMMARY = "coveralls - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "coveralls"
HOMEPAGE = "http://rubygems.org/gems/coveralls"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=763cc1871f63118570dcc7cd19f87d95"


SRC_URI[md5sum] = "80680dac8dd3513c07664133f7f681f7"
SRC_URI[sha256sum] = "887bfcbd9a735c68c5e846ee9916061899d07b23901e1917bc07b6d401bdcbcf"

PR = "r0"

inherit rubygems
