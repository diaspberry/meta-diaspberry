SUMMARY = "simple_captcha2 - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "simple_captcha2"
HOMEPAGE = "http://rubygems.org/gems/simple_captcha2"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "7e57d43f6a8d36fd86da56fd5bbd3676"
SRC_URI[sha256sum] = "c2432b7dd3ade6f7a2402a40af46eba80ab7c587ecd8b1fbdcb05eaecb8ec3d8"

PR = "r0"

inherit rubygems
