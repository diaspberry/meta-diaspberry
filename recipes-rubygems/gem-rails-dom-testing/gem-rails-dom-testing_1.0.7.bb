SUMMARY = "rails-dom-testing - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-dom-testing"
HOMEPAGE = "http://rubygems.org/gems/rails-dom-testing"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=5377d7b6eb2409afd4e0e78a8cafd435"


SRC_URI[md5sum] = "4ad604c921f2075c352814f8d75e4e40"
SRC_URI[sha256sum] = "6813821425ff44ae3188162d0bae1a2ae08080fc1a584860bf78d50190a112ed"

PR = "r0"

inherit rubygems
