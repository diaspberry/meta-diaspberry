SUMMARY = "nested_form - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "nested_form"
HOMEPAGE = "http://rubygems.org/gems/nested_form"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=9300d2b77e649642870990776dfd8251"


SRC_URI[md5sum] = "46ad2dfbc557d3541a699d622ffa5501"
SRC_URI[sha256sum] = "b1c468d7eac781235861c2f74fc9f675df0c4d915d5724aaf7fd29f7891c0538"

PR = "r0"

inherit rubygems
