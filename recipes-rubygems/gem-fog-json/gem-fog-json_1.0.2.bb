SUMMARY = "fog-json - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-json"
HOMEPAGE = "http://rubygems.org/gems/fog-json"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=d21fce5e064291db3821bc100f9d256c"


SRC_URI[md5sum] = "0cdeddae7534691c688f2272ec202282"
SRC_URI[sha256sum] = "19006b42ac58cc71442e97d00de454824245b3780bb091cfa97e4a25db9cbb29"

PR = "r0"

inherit rubygems
