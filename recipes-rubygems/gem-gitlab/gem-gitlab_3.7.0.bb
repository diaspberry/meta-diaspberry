SUMMARY = "gitlab - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "gitlab"
HOMEPAGE = "http://rubygems.org/gems/gitlab"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=d2afdd74e4bbe04df771a33bbbe15159"


SRC_URI[md5sum] = "13d89175262be690b8acc61d035df532"
SRC_URI[sha256sum] = "018c75a96bfd937b303db8951a69d81b90440c0c67f2c18799df86b8d3e36cd3"

PR = "r0"

inherit rubygems
