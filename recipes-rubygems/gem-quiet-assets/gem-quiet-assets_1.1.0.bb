SUMMARY = "quiet_assets - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "quiet_assets"
HOMEPAGE = "http://rubygems.org/gems/quiet_assets"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4b71e629d89270aa4ed5a15d14174ffd"


SRC_URI[md5sum] = "949e5a192205e261dee6e010cece4edb"
SRC_URI[sha256sum] = "57cd58358b5d18fe4be4e6f9267b7b33203fc1458ac4dbaa52bf8d8d75254d63"

PR = "r0"

inherit rubygems
