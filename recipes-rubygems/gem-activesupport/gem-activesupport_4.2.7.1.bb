SUMMARY = "activesupport - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "activesupport"
HOMEPAGE = "http://rubygems.org/gems/activesupport"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=2f049be37cb97cf3f14e50364ac0bc2f"


SRC_URI[md5sum] = "fd4b9e71e0e1cb3e5981ec615deed07b"
SRC_URI[sha256sum] = "241bbcefbd472a2685e84952ca9c0dbec5665121ea88b312602c777ba608babd"

PR = "r0"

inherit rubygems
