SUMMARY = "guard-rubocop - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "guard-rubocop"
HOMEPAGE = "http://rubygems.org/gems/guard-rubocop"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f3f5b2ff1d83ca59bd02f36fc4ce419c"


SRC_URI[md5sum] = "0c05d94cd845a1a5d43564d51f945401"
SRC_URI[sha256sum] = "55a13be2c79a766c47a6563020098e3988456a48d25a1223fcac4f562c4f1740"

PR = "r0"

inherit rubygems
