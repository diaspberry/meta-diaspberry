SUMMARY = "yard - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "yard"
HOMEPAGE = "http://rubygems.org/gems/yard"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://lib/yard/rubygems/backports/LICENSE.txt;md5=6f3e52e6406da4fbe2661e6762533a32"


SRC_URI[md5sum] = "55559a424c6bc58cba9a8affdbc86dc9"
SRC_URI[sha256sum] = "3da10884b94fa25b7476f619b1d2cfb61290e10673965c545975630cd88a46b6"

PR = "r0"

inherit rubygems
