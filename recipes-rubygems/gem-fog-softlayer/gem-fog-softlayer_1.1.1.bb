SUMMARY = "fog-softlayer - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-softlayer"
HOMEPAGE = "http://rubygems.org/gems/fog-softlayer"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ea11b710b55713f2f88243761783d26c"


SRC_URI[md5sum] = "152e285a92268211c933b8db4146fdec"
SRC_URI[sha256sum] = "3f05e0d6ccc6ba135c34173a0bcd7239145f9f69441d6f1ae903b90af87c06cc"

PR = "r0"

inherit rubygems
