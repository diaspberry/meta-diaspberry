SUMMARY = "ipaddress - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "ipaddress"
HOMEPAGE = "http://rubygems.org/gems/ipaddress"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=4e3f767de86883ec76018c80bf7cd875"


SRC_URI[md5sum] = "15c3ce3bcf68ecaee8d25070b033bcac"
SRC_URI[sha256sum] = "85640c4f9194c26937afc8c78e3074a8e7c97d5d1210358d1440f01034d006f5"

PR = "r0"

inherit rubygems
