SUMMARY = "crack - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "crack"
HOMEPAGE = "http://rubygems.org/gems/crack"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5157095f2044e64787dee8a3b610e20e"


SRC_URI[md5sum] = "342f8ace93b2029ff090811be48182f5"
SRC_URI[sha256sum] = "5318ba8cd9cf7e0b5feb38948048503ba4b1fdc1b6ff30a39f0a00feb6036b29"

PR = "r0"

inherit rubygems
