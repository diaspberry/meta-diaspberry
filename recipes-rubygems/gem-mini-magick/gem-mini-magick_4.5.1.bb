SUMMARY = "mini_magick - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "mini_magick"
HOMEPAGE = "http://rubygems.org/gems/mini_magick"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=a0ec5b3e1f09b31b15b43d986f653dba"


SRC_URI[md5sum] = "b363c7c50424ef0b15f21d3224627012"
SRC_URI[sha256sum] = "17352cb1fc709eacfee886af2946c87e9797c119132ba63d3040ee246899a9a8"

PR = "r0"

inherit rubygems
