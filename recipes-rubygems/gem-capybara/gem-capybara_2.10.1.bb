SUMMARY = "capybara - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "capybara"
HOMEPAGE = "http://rubygems.org/gems/capybara"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://License.txt;md5=79150005093fcfc7b2ca85a435d7cf68"


SRC_URI[md5sum] = "689242c4a1c8ee82f193dcb297a960c1"
SRC_URI[sha256sum] = "f6ad4dc40a84f2d90b8625816f25cd53bf15e34b0af02754aa6dc736ed58aab7"

PR = "r0"

inherit rubygems
