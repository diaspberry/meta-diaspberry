SUMMARY = "sprockets-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sprockets-rails"
HOMEPAGE = "http://rubygems.org/gems/sprockets-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=cad40ecdc3531a90928f70c2a86e0435"


SRC_URI[md5sum] = "0c577db4dd120b0a15343774fe9fb93b"
SRC_URI[sha256sum] = "968794c910cc395ae10a68e3d4f5801f946b7698103e42ed49f7cad67d3654ef"

PR = "r0"

inherit rubygems
