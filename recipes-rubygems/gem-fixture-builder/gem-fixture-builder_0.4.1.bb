SUMMARY = "fixture_builder - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fixture_builder"
HOMEPAGE = "http://rubygems.org/gems/fixture_builder"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=e2818073276d0c1fdc48446b1412b3f2"


SRC_URI[md5sum] = "2a24d2994c3c4abd2459c8f42c30bb17"
SRC_URI[sha256sum] = "5e1f632e927a08126bb49207deafaf8c019a554f0db62ab6ab3ce61dee8b0c4c"

PR = "r0"

inherit rubygems
