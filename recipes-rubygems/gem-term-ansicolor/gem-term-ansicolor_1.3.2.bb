SUMMARY = "term-ansicolor - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "term-ansicolor"
HOMEPAGE = "http://rubygems.org/gems/term-ansicolor"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COPYING;md5=393a5ca445f6965873eca0259a17f833"


SRC_URI[md5sum] = "d1e7b8b6a330600c5d311076f80c33e8"
SRC_URI[sha256sum] = "da7ba80ae2dad077736a48dac18ae9d859990e9ed6b952a276e79659a55fab79"

PR = "r0"

inherit rubygems
