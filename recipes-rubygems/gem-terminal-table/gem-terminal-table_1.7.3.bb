SUMMARY = "terminal-table - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "terminal-table"
HOMEPAGE = "http://rubygems.org/gems/terminal-table"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "1d97f7e772f7d336039f94fbbeb49fdb"
SRC_URI[sha256sum] = "f10d5ff88f5596dfeb45d2cdf1ad35b8b8e347f58bcc7307a270af44176885a5"

PR = "r0"

inherit rubygems
