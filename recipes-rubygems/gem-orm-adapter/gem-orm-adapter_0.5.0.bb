SUMMARY = "orm_adapter - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "orm_adapter"
HOMEPAGE = "http://rubygems.org/gems/orm_adapter"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4189f0604311287e1163104c1e18ab1d"


SRC_URI[md5sum] = "08702bf6f1f0c548e4d29aa236ef2a1c"
SRC_URI[sha256sum] = "aa5d0be5d540cbb46d3a93e88061f4ece6a25f6e97d6a47122beb84fe595e9b9"

PR = "r0"

inherit rubygems
