SUMMARY = "equalizer - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "equalizer"
HOMEPAGE = "http://rubygems.org/gems/equalizer"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=91ed5f459e9d906d6b9b00c567d8dc19"


SRC_URI[md5sum] = "5c7a54a6dcafc5da2e8ac89482a366ae"
SRC_URI[sha256sum] = "a1cffc50fc7448a0b16c66e4147c4973c530858ec532b48244349fac99e00786"

PR = "r0"

inherit rubygems
