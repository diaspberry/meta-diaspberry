SUMMARY = "connection_pool - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "connection_pool"
HOMEPAGE = "http://rubygems.org/gems/connection_pool"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=52789255e9a79d4ae4a5ab6831d80fd1"


SRC_URI[md5sum] = "43e9c5caa0510e8f0f7a382dff859b2e"
SRC_URI[sha256sum] = "bee6c77ecdc149c125b89fcf76341036ae293df169536cd9af25da34e6584bac"

PR = "r0"

inherit rubygems
