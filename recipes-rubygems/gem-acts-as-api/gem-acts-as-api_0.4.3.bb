SUMMARY = "acts_as_api - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "acts_as_api"
HOMEPAGE = "http://rubygems.org/gems/acts_as_api"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://spec/shared_engine/MIT-LICENSE;md5=1c631891be87b677e141d03975610422"


SRC_URI[md5sum] = "e5976a3bbb07790e1f37fee90b8d1b52"
SRC_URI[sha256sum] = "4935e7db86c8cad5f43f5a80b65a3be5bb7f83693d4062dd01141fb4eafe2134"

PR = "r0"

inherit rubygems
