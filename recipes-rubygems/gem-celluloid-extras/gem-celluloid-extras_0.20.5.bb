SUMMARY = "celluloid-extras - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "celluloid-extras"
HOMEPAGE = "http://rubygems.org/gems/celluloid-extras"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=c593826d90d9bf33eae341a7a63e7107"


SRC_URI[md5sum] = "6621ef251fae04913a2d7f61c796ee97"
SRC_URI[sha256sum] = "cf9ea7203793a25c20a7cb100c663b2480f25978c5ce41c696e85ca7ed7e0a1d"

PR = "r0"

inherit rubygems
