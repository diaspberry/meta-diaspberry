SUMMARY = "ruby-progressbar - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "ruby-progressbar"
HOMEPAGE = "http://rubygems.org/gems/ruby-progressbar"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=e8a88841eadf3c6c49cec814666ae1e7"


SRC_URI[md5sum] = "07f7eddceb272e9b0c8ea123c489f0e8"
SRC_URI[sha256sum] = "95ded755295440de814704970d7ccaf3cb259854534f03a03a6d05918f3eece3"

PR = "r0"

inherit rubygems
