SUMMARY = "compass-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "compass-rails"
HOMEPAGE = "http://rubygems.org/gems/compass-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6ac7fc11f74e3eaea21cd5ab34b0740b"


SRC_URI[md5sum] = "74e15867d4a1d78b7f728f499154515c"
SRC_URI[sha256sum] = "fe331fb032ebe447e97c982657b4bf90cc8d243475c06b2747811abb80d2981d"

PR = "r0"

inherit rubygems
