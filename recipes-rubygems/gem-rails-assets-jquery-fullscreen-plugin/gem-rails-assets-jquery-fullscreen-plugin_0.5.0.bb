SUMMARY = "rails-assets-jquery-fullscreen-plugin - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-jquery-fullscreen-plugin"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-jquery-fullscreen-plugin"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "0d348461f2ac7d0332a249bfaaab4b15"
SRC_URI[sha256sum] = "a8347dd5a71e3570d3b973b572ae814f58a99ae13eb4c3cd4d57d11234c1bb51"

PR = "r0"

inherit rubygems
