SUMMARY = "fog-xml - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-xml"
HOMEPAGE = "http://rubygems.org/gems/fog-xml"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=64bf1c88256c6bc237b48f00229a1d6d"


SRC_URI[md5sum] = "9405d5edef34cebd446bc3745b7d5452"
SRC_URI[sha256sum] = "0a3b624ae6503d167a1fdfb5d0da669b3d98c7e301a6092e22ff10f5ffd2e694"

PR = "r0"

inherit rubygems
