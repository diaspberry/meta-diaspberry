SUMMARY = "will_paginate - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "will_paginate"
HOMEPAGE = "http://rubygems.org/gems/will_paginate"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=bd7c7029ef620d44ac919e02ac712448"


SRC_URI[md5sum] = "849c2dcee77cb9bbe2edae6f7e4b16c6"
SRC_URI[sha256sum] = "d204bac6b85c34e6c13f176583ccef1fdfdbd802658271d1b84791d7ca0b2f06"

PR = "r0"

inherit rubygems
