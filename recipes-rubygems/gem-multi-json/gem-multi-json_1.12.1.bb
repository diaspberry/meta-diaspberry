SUMMARY = "multi_json - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "multi_json"
HOMEPAGE = "http://rubygems.org/gems/multi_json"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=77e7a5e1b7c128037628b4bc5324c64a"


SRC_URI[md5sum] = "7748bcf54c2b1a7034b69f36729a506b"
SRC_URI[sha256sum] = "b387722b0a31fff619a2682c7011affb5a13fed2cce240c75c5d6ca3e910ecf2"

PR = "r0"

inherit rubygems
