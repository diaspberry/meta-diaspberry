SUMMARY = "fog-sakuracloud - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-sakuracloud"
HOMEPAGE = "http://rubygems.org/gems/fog-sakuracloud"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=15c5984bf0eff3ce3e684bf34ffb8da0"


SRC_URI[md5sum] = "ce294c382ed8fe58faf1ce1a318dc31c"
SRC_URI[sha256sum] = "adc6acbe32921835aa2af8a265d5076d251372184f04a4be025d97a993d57922"

PR = "r0"

inherit rubygems
