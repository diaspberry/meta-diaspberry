SUMMARY = "diaspora_federation-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "diaspora_federation-rails"
HOMEPAGE = "http://rubygems.org/gems/diaspora_federation-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6ba6a7f44428f5b06245f2079a852275"


SRC_URI[md5sum] = "0ef0edb2e2e8a7f616a8e8148e9a81cc"
SRC_URI[sha256sum] = "d0db1c899d2b8a78398c2434f6660d7008696d62b8aefa67ebd319d4bd965f7d"

PR = "r0"

inherit rubygems
