SUMMARY = "unicorn - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "unicorn"
HOMEPAGE = "http://rubygems.org/gems/unicorn"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COPYING;md5=0c7051aef9219dc7237f206c5c4179a7"


SRC_URI[md5sum] = "89053d5267064a60a93ac00da76a6b99"
SRC_URI[sha256sum] = "5b1c6a38d3503ec54d7acb6da89957ac8cba6b00ac787b6de683fb80467a9be5"

PR = "r0"

inherit rubygems
