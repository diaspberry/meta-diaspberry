SUMMARY = "fog-voxel - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-voxel"
HOMEPAGE = "http://rubygems.org/gems/fog-voxel"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=092994879187cbaf2adb791181109e2a"


SRC_URI[md5sum] = "2ba5a21fee89631d8d2887b51363aa7a"
SRC_URI[sha256sum] = "fdb9baeb000063742c523bd2a3d4e7800ab8b394369983f795c4f954a46d5383"

PR = "r0"

inherit rubygems
