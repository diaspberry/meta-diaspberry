SUMMARY = "rails-assets-jquery.ui - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-jquery.ui"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-jquery.ui"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "16b2934eabd8e7b2d0f07c90da74c813"
SRC_URI[sha256sum] = "4ad979a4bed4a78d6f4623f9df5b98adcdce953a2b1199632024c224969b8975"

PR = "r0"

inherit rubygems
