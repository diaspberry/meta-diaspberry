SUMMARY = "rails-i18n - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-i18n"
HOMEPAGE = "http://rubygems.org/gems/rails-i18n"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE.txt;md5=665031d7e62c67255ee439310631e42e"


SRC_URI[md5sum] = "822b97ed85b331859a06e3ac270e3186"
SRC_URI[sha256sum] = "b92201cc65ff074b3009893762e90ec2f158ca041fccdea1904579f32f41aad6"

PR = "r0"

inherit rubygems
