SUMMARY = "spring-commands-cucumber - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "spring-commands-cucumber"
HOMEPAGE = "http://rubygems.org/gems/spring-commands-cucumber"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=59a5909e63c947d33a53de609a08de46"


SRC_URI[md5sum] = "d20c89f8662f5ef2474603efa7e9b459"
SRC_URI[sha256sum] = "2ab1d078847e3dbfd168c0ad2e7292c0d559f5f1d4b04b26b15b0b5df70b8857"

PR = "r0"

inherit rubygems
