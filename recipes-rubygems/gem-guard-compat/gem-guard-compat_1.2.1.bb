SUMMARY = "guard-compat - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "guard-compat"
HOMEPAGE = "http://rubygems.org/gems/guard-compat"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=68439ee872b0b899d495cce831de3a36"


SRC_URI[md5sum] = "dc2e4ea8a599f3ec4fd863eb5e9d6c59"
SRC_URI[sha256sum] = "3ad21ab0070107f92edfd82610b5cdc2fb8e368851e72362ada9703443d646fe"

PR = "r0"

inherit rubygems
