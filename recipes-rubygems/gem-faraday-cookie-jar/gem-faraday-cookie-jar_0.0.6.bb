SUMMARY = "faraday-cookie_jar - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "faraday-cookie_jar"
HOMEPAGE = "http://rubygems.org/gems/faraday-cookie_jar"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=b90bc684ef2518794f21ae39c3f065c6"


SRC_URI[md5sum] = "f570028f3a7437e9ae4d84f6cdd48d46"
SRC_URI[sha256sum] = "66c7d899faa821bfb166dd93b5f928b184324b4dc7c89b67fb4619424c7f24b6"

PR = "r0"

inherit rubygems
