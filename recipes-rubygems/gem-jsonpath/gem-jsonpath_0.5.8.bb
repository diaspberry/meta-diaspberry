SUMMARY = "jsonpath - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "jsonpath"
HOMEPAGE = "http://rubygems.org/gems/jsonpath"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "d3352feef24e5c809800667f214f15b1"
SRC_URI[sha256sum] = "ae8dc4a4f4dc5eecf72f542ac622a78b0ec46432aa22efcf28587bda4fcb90bf"

PR = "r0"

inherit rubygems
