SUMMARY = "jasmine - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "jasmine"
HOMEPAGE = "http://rubygems.org/gems/jasmine"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT.LICENSE;md5=61a8b8a6e27bef35731183250ca1dc57"


SRC_URI[md5sum] = "fef46cf0dc3857ac2552b2bb1618af98"
SRC_URI[sha256sum] = "c7f7e6289a53b25b819c10cab9f36d7f4c8bc33e80bc2993f43c14a44d2749d5"

PR = "r0"

inherit rubygems
