SUMMARY = "ruby-oembed - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "ruby-oembed"
HOMEPAGE = "http://rubygems.org/gems/ruby-oembed"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=391c01508b12b798030eab30034cf4e9"


SRC_URI[md5sum] = "266ffcc4191c75028924b0a6c7e2e53b"
SRC_URI[sha256sum] = "6eab65dc0595edf51a27a715d646250fdd1c857dd4cb50dd25c3e59f2ef90f67"

PR = "r0"

inherit rubygems
