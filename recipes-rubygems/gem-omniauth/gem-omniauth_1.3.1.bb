SUMMARY = "omniauth - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "omniauth"
HOMEPAGE = "http://rubygems.org/gems/omniauth"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=bcf4d840c68e250bb519abfd2b409fa6"


SRC_URI[md5sum] = "8758b2c79b5e53208a7ba9461a8cb0ef"
SRC_URI[sha256sum] = "579884ac0911e844b9fd3009961fd20b5e5aa11efb6e33cf02213a36ffeb586f"

PR = "r0"

inherit rubygems
