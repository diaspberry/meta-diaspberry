SUMMARY = "gon - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "gon"
HOMEPAGE = "http://rubygems.org/gems/gon"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dfa33ae8b2a00291c17dcee161627725"


SRC_URI[md5sum] = "b1808e834f3353f1f6a96a088b475843"
SRC_URI[sha256sum] = "ffd9d4721a9508e2c88594ed28ccafed0feb28240ba739bb282f3b9e3c35aeca"

PR = "r0"

inherit rubygems
