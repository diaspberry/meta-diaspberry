SUMMARY = "fog-aws - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-aws"
HOMEPAGE = "http://rubygems.org/gems/fog-aws"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=c90b00d7b880dfc422cb720f602a5de0"


SRC_URI[md5sum] = "2de5b883ba531cce4a8c5ff1018e2a74"
SRC_URI[sha256sum] = "ef273b4db1b5d142d046ca851bb5d48130f53ea6768990180d0354c47387b046"

PR = "r0"

inherit rubygems
