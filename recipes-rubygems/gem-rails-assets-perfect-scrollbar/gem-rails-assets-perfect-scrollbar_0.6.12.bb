SUMMARY = "rails-assets-perfect-scrollbar - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-perfect-scrollbar"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-perfect-scrollbar"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "29dc34a3378c26b3ee2d15ed5eed3826"
SRC_URI[sha256sum] = "1430065c54317e11eda1f3ee8458305e0239d6e3c5179aade66e63064de4ef14"

PR = "r0"

inherit rubygems
