SUMMARY = "securecompare - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "securecompare"
HOMEPAGE = "http://rubygems.org/gems/securecompare"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=26d0af31133fb47dbc47dddfdce61b5a"


SRC_URI[md5sum] = "fcd094df659d05ca97b7308f546d5487"
SRC_URI[sha256sum] = "cb0c6599deaaedf6d28f8d88538b06e7198c4826b1b8edb1dbeb44a2162fc62b"

PR = "r0"

inherit rubygems
