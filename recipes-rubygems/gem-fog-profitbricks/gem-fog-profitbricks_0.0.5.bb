SUMMARY = "fog-profitbricks - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-profitbricks"
HOMEPAGE = "http://rubygems.org/gems/fog-profitbricks"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=11d77152b55026d4c0d97051dc799378"


SRC_URI[md5sum] = "ebf2aff5f45a80887c0008df18ddfb86"
SRC_URI[sha256sum] = "96f9dc91764e3fdfb2d9051185b00627969f8043d28d4a76106f57d684c69a94"

PR = "r0"

inherit rubygems
