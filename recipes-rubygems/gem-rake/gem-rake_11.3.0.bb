SUMMARY = "rake - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rake"
HOMEPAGE = "http://rubygems.org/gems/rake"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=b217e3354f829a186a07233cd480fbee"


SRC_URI[md5sum] = "2d075235213a2b7ebf1c4161208a2c36"
SRC_URI[sha256sum] = "8af6541547dd7e031fa78c1c978084862b7bc3ab670c2b2f539054e8d9aad232"

PR = "r0"

inherit rubygems
