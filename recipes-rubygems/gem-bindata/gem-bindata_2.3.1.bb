SUMMARY = "bindata - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "bindata"
HOMEPAGE = "http://rubygems.org/gems/bindata"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COPYING;md5=64d7b6395985a247282934726ca0583a"


SRC_URI[md5sum] = "a88fdabb8d784e49d40d8dfca3196f5f"
SRC_URI[sha256sum] = "9cada01e178320b5b404ee1d136f3cf8eaee8f643abf71395cce1b1304d5d6a5"

PR = "r0"

inherit rubygems
