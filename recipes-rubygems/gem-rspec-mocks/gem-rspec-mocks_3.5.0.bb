SUMMARY = "rspec-mocks - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rspec-mocks"
HOMEPAGE = "http://rubygems.org/gems/rspec-mocks"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=3d96800bd9b5ffa0ed091438eaea6f01"


SRC_URI[md5sum] = "56c920c147a369c58d2f9367c9797714"
SRC_URI[sha256sum] = "44ccda8a3240bf70d77f408d759fd980749edf6be51fd2a4cc9c27b8a39e835a"

PR = "r0"

inherit rubygems
