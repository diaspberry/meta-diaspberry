SUMMARY = "pronto-rubocop - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "pronto-rubocop"
HOMEPAGE = "http://rubygems.org/gems/pronto-rubocop"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b0be4887c19ae74609f7ff9ca57ebb7c"


SRC_URI[md5sum] = "5d6100258edb28238e27debb793ddd31"
SRC_URI[sha256sum] = "be9d69cb5a5986e4130930c3967f1354e882c3bcbcf1aad80076db449ae47919"

PR = "r0"

inherit rubygems
