SUMMARY = "buftok - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "buftok"
HOMEPAGE = "http://rubygems.org/gems/buftok"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=8a960b08d972f43f91ae84a6f00dcbfb"


SRC_URI[md5sum] = "86a3291cfdaec13ce2cc11d26b1773f6"
SRC_URI[sha256sum] = "bad760334631e15b8eea608468709d3265e087703b5af0532f6583e277f0fae7"

PR = "r0"

inherit rubygems
