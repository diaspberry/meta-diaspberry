SUMMARY = "activemodel - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "activemodel"
HOMEPAGE = "http://rubygems.org/gems/activemodel"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=c1a401c5778f1549ecfe3452a26d6c19"


SRC_URI[md5sum] = "c02d175bcffd04043aa8c6adb746c322"
SRC_URI[sha256sum] = "65a7631d487b9642c6877dd404667991e36cdd75e588406c4d4c435557059f29"

PR = "r0"

inherit rubygems
