SUMMARY = "guard-rspec - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "guard-rspec"
HOMEPAGE = "http://rubygems.org/gems/guard-rspec"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=3c50af3a3eaad21343dfaea5d339e756"


SRC_URI[md5sum] = "9f8557ce999721e76719eb4c8f430155"
SRC_URI[sha256sum] = "a47ba03cbd1e3c71e6ae8645cea97e203098a248aede507461a43e906e2f75ca"

PR = "r0"

inherit rubygems
