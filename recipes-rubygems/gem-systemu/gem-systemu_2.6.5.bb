SUMMARY = "systemu - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "systemu"
HOMEPAGE = "http://rubygems.org/gems/systemu"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e5d49a6ec236382a5e71349bf097db9d"


SRC_URI[md5sum] = "4972263c3be77f2a429a9ce24982b91b"
SRC_URI[sha256sum] = "01f7d014b1453b28e5781e15c4d7d63fc9221c29b174b7aae5253207a75ab33e"

PR = "r0"

inherit rubygems
