SUMMARY = "rack - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack"
HOMEPAGE = "http://rubygems.org/gems/rack"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COPYING;md5=ad65b6b9669213d45aa35a0730d58ac2"


SRC_URI[md5sum] = "7f11121a95fe4e59cd86af2b791a3590"
SRC_URI[sha256sum] = "455ec4545a54b40dae9937bc5f61ee0e32134191cc1ef9a7959a19ec4b127a25"

PR = "r0"

inherit rubygems
