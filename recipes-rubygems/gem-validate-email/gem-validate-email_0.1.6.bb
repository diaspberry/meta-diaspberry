SUMMARY = "validate_email - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "validate_email"
HOMEPAGE = "http://rubygems.org/gems/validate_email"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "5d54a9b4b7f8e426a2b536c96d7e9adb"
SRC_URI[sha256sum] = "9dfe9016d527b17a8d3a6e95e4dc50a125400eef899d13d4cc2a254393f82ee4"

PR = "r0"

inherit rubygems
