SUMMARY = "versionist - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "versionist"
HOMEPAGE = "http://rubygems.org/gems/versionist"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "f560837a6f077da6adadb101c2bb9849"
SRC_URI[sha256sum] = "327e4a3e83de62c40cb061e8f689fe9b7b170b22b84a80223cc3efc2254619d9"

PR = "r0"

inherit rubygems
