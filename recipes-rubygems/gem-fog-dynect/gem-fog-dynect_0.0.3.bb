SUMMARY = "fog-dynect - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-dynect"
HOMEPAGE = "http://rubygems.org/gems/fog-dynect"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=a6106da6133b52c427015215716d656b"


SRC_URI[md5sum] = "8b4ff4d705a9c6dfbacfd78ef6a7e0e2"
SRC_URI[sha256sum] = "28b5e3f64f711d70461cc5a2d8c1cd078feb4c5bc498b7c7a06c2d27bf08bb2e"

PR = "r0"

inherit rubygems
