SUMMARY = "fog-core - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-core"
HOMEPAGE = "http://rubygems.org/gems/fog-core"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=e761d5f29cfc12ec8524b306bb3b0abd"


SRC_URI[md5sum] = "ac1a1f95baca6b205c33b482e69e6960"
SRC_URI[sha256sum] = "e70365a03431692a2f9ae2ad1da1fea572b6e6ed1ca0f6171a1987da74be93ba"

PR = "r0"

inherit rubygems
