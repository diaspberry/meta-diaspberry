SUMMARY = "simple_oauth - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "simple_oauth"
HOMEPAGE = "http://rubygems.org/gems/simple_oauth"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=b90064cd7028f87dd02245ccf2216592"


SRC_URI[md5sum] = "e7557cbe6c2d533f1f1dd68beaf475d4"
SRC_URI[sha256sum] = "147992e2c872c5b3cb97292e4a4ef099c9dbb76112760002ad93f1534d8c8937"

PR = "r0"

inherit rubygems
