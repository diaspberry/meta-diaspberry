SUMMARY = "little-plugger - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "little-plugger"
HOMEPAGE = "http://rubygems.org/gems/little-plugger"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "8b1cf294a87eaabd12d5326bc13d7fe0"
SRC_URI[sha256sum] = "d5f347c00d9d648040ef7c17d6eb09d3d0719adf19ca30d1a3b6fb26d0a631bb"

PR = "r0"

inherit rubygems
