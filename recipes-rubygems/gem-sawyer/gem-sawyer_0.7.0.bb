SUMMARY = "sawyer - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sawyer"
HOMEPAGE = "http://rubygems.org/gems/sawyer"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=6dac566831f0538bd5a9faa023219b27"


SRC_URI[md5sum] = "855b850bc12ab805e8dbc3d66d2c03ac"
SRC_URI[sha256sum] = "72e855027c812f2cad7f4fa4746cab07727dde91d75516d353c155002846c4b2"

PR = "r0"

inherit rubygems
