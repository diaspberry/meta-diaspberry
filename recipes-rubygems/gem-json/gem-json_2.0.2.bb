SUMMARY = "json - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "json"
HOMEPAGE = "http://rubygems.org/gems/json"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

SRC_URI[md5sum] = "6f3137d05d24f9bb1c7f9e3dd942cbee"
SRC_URI[sha256sum] = "400f60ac8282da80764c5d6fbb04c096390a85950bb488652abc1eb993b411d2"

PR = "r0"

inherit rubygems
