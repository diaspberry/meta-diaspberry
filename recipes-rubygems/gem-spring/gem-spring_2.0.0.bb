SUMMARY = "spring - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "spring"
HOMEPAGE = "http://rubygems.org/gems/spring"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ec95fe1f7cc84c519d4fdff760c08e93"


SRC_URI[md5sum] = "f3701230ae41937c178e0e1542c3b3de"
SRC_URI[sha256sum] = "8a73238f5f1de29b2846f56c5c31332ff37d5b62dca8ff46c7d8d6be29f1afb1"

PR = "r0"

inherit rubygems
