SUMMARY = "fog-brightbox - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-brightbox"
HOMEPAGE = "http://rubygems.org/gems/fog-brightbox"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=d22dd08817b039251caace89f542acd4"


SRC_URI[md5sum] = "312048b6d4be23dc46f1f2310145a3b4"
SRC_URI[sha256sum] = "6dce7541945b18fa9c3f09b6f60503c59bdbfec8ac8154556861c1834a5ff95c"

PR = "r0"

inherit rubygems
