SUMMARY = "rspec-support - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rspec-support"
HOMEPAGE = "http://rubygems.org/gems/rspec-support"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=e4c6d4a0edc4927fd19ea2608a4b5fe5"


SRC_URI[md5sum] = "d3b1e5c0d8fd9ec7cdc5d443385e7c0a"
SRC_URI[sha256sum] = "2017eccd6868fa7c6d5373045dcad8d9b8ecb4fb533c55c7295e1cd2c61c6e83"

PR = "r0"

inherit rubygems
