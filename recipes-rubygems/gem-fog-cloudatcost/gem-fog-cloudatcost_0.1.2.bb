SUMMARY = "fog-cloudatcost - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-cloudatcost"
HOMEPAGE = "http://rubygems.org/gems/fog-cloudatcost"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dc7983e3553764b96ae9b66c08d07a0f"


SRC_URI[md5sum] = "e0e8b8b718b1c88e952427d2787bdbe6"
SRC_URI[sha256sum] = "fec5072aa186d3859f93d4dbd35538e7461bcaf115fe37bbb2ad3fd44b57408c"

PR = "r0"

inherit rubygems
