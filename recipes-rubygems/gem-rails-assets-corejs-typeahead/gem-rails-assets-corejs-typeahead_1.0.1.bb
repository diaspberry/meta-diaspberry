SUMMARY = "rails-assets-corejs-typeahead - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-corejs-typeahead"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-corejs-typeahead"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "cb85797dd4788551666f273ef05afddc"
SRC_URI[sha256sum] = "5add150a7980b57518c990f13f8881a1680d1fca7546853b06b0af2fdcb3fa4e"

PR = "r0"

inherit rubygems
