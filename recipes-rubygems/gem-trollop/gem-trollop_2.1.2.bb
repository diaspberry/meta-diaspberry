SUMMARY = "trollop - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "trollop"
HOMEPAGE = "http://rubygems.org/gems/trollop"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "6ff25bc7f93497c107b67f9ae5bf73b4"
SRC_URI[sha256sum] = "88422e8137b1e635ed07f6b8480c2c2a16d3ac1288023688c4da20d786f12510"

PR = "r0"

inherit rubygems
