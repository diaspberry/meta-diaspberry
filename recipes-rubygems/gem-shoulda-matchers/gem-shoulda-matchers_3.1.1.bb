SUMMARY = "shoulda-matchers - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "shoulda-matchers"
HOMEPAGE = "http://rubygems.org/gems/shoulda-matchers"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=a54b206ee05c09bc7cb861f73373c090"


SRC_URI[md5sum] = "0e71053b214adcf82228bcc05437e7bf"
SRC_URI[sha256sum] = "f8f73357eb6c51b03cb0e76cf425092d3b96a61766dc94a9df02e5959a68c6b1"

PR = "r0"

inherit rubygems
