SUMMARY = "devise - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "devise"
HOMEPAGE = "http://rubygems.org/gems/devise"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=d381c176e2f94d6c2aba81c60d38d826"


SRC_URI[md5sum] = "0fa5410e26c74bc6fa3bb8d35adf0738"
SRC_URI[sha256sum] = "e0b6a3828368e2b9796361395e90c48bf92ff859502ec9d1a86c3e83c2e0b810"

PR = "r0"

inherit rubygems
