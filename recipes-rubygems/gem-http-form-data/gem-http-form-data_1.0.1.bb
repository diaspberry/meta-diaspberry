SUMMARY = "http-form_data - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "http-form_data"
HOMEPAGE = "http://rubygems.org/gems/http-form_data"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=20472d20827d6a78b9eac69c680faf6f"


SRC_URI[md5sum] = "4111fbd6b6a0353fbd39b04ddf99c4f9"
SRC_URI[sha256sum] = "09f644d2b80ee67f9957561de698a585bc8a6a86e9b7da96251639c691872683"

PR = "r0"

inherit rubygems
