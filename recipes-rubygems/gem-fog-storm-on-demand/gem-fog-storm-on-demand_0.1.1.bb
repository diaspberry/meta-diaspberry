SUMMARY = "fog-storm_on_demand - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-storm_on_demand"
HOMEPAGE = "http://rubygems.org/gems/fog-storm_on_demand"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=e55abf9d276423a641feaefe874897a8"


SRC_URI[md5sum] = "96365abf2c05360499a0a85656b714e8"
SRC_URI[sha256sum] = "7eecde37f231cfa679b53a7f8508b1db47d38f2dc6d1e8bd582581c8500f2e3a"

PR = "r0"

inherit rubygems
