SUMMARY = "fog-vsphere - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-vsphere"
HOMEPAGE = "http://rubygems.org/gems/fog-vsphere"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=4361303be084a53e24b045998c449c43"


SRC_URI[md5sum] = "07ba024305fd86b6fbe7f8108da395a5"
SRC_URI[sha256sum] = "7770e47cd322c1d90d0c887682e968d9c12a08f9c96e7189818c5203f5186153"

PR = "r0"

inherit rubygems
