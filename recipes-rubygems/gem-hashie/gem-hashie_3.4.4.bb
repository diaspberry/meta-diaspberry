SUMMARY = "hashie - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "hashie"
HOMEPAGE = "http://rubygems.org/gems/hashie"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dd1ec82dd4ea7ed5eebb24bebec9f068"


SRC_URI[md5sum] = "453953189a66173e7e3bbab9a551cfe5"
SRC_URI[sha256sum] = "9dd69627730107041421f453eebef585251a50f6ec2720de0bce2443736598e2"

PR = "r0"

inherit rubygems
