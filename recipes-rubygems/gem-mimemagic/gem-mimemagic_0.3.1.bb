SUMMARY = "mimemagic - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "mimemagic"
HOMEPAGE = "http://rubygems.org/gems/mimemagic"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=498905401809be7aa11502ad8d54297a"


SRC_URI[md5sum] = "5f8234dafea4fde5fabd69cefb8dff3e"
SRC_URI[sha256sum] = "8fb981c19040ccc22888f17f2665ae829bc2fa0983b644c6947d4494b7d0a379"

PR = "r0"

inherit rubygems
