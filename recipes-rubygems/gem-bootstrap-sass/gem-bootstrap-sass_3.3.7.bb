SUMMARY = "bootstrap-sass - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "bootstrap-sass"
HOMEPAGE = "http://rubygems.org/gems/bootstrap-sass"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5e3a3a4f0e0e106928d906fb5b8979dd"


SRC_URI[md5sum] = "863b73c55d479ad5e612aeef0f5dd9b1"
SRC_URI[sha256sum] = "a92f02af5be165be7e9934d1dfd597ab7ee64de96595b073b0b835c58c5b89ad"

PR = "r0"

inherit rubygems
