SUMMARY = "sidekiq - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "sidekiq"
HOMEPAGE = "http://rubygems.org/gems/sidekiq"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COMM-LICENSE;md5=29dce5a656dc1a4a6cf640b33bedd6b2"


SRC_URI[md5sum] = "e808b0a6fb9064c1cd90e9e26fce6804"
SRC_URI[sha256sum] = "22aba7a8695521b7f00a0ef1492bbfceb1b176063c2139f5829a4a14e250646d"

PR = "r0"

inherit rubygems
