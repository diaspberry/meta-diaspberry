SUMMARY = "omniauth-oauth2 - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "omniauth-oauth2"
HOMEPAGE = "http://rubygems.org/gems/omniauth-oauth2"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=cbecc5eadf80561d7101820f252c4c00"


SRC_URI[md5sum] = "02082e2a7471864f8bd28935f57ae150"
SRC_URI[sha256sum] = "c525d06d6c263a71dfd5b78513a7be5c16d5616ebe918133f7675487cb5bd32b"

PR = "r0"

inherit rubygems
