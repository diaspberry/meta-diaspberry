SUMMARY = "shellany - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "shellany"
HOMEPAGE = "http://rubygems.org/gems/shellany"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=68439ee872b0b899d495cce831de3a36"


SRC_URI[md5sum] = "e5eb46d8d143d48beef195cb025e34de"
SRC_URI[sha256sum] = "0e127a9132698766d7e752e82cdac8250b6adbd09e6c0a7fbbb6f61964fedee7"

PR = "r0"

inherit rubygems
