SUMMARY = "jasmine-jquery-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "jasmine-jquery-rails"
HOMEPAGE = "http://rubygems.org/gems/jasmine-jquery-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=70038c2be73bf2b0c2c72966a343a84f"


SRC_URI[md5sum] = "adfd7305703290cd89a6be0b3fc1f301"
SRC_URI[sha256sum] = "9b4a939ac76df91a8e00e6a4d91acdc0b4bf8ed2a6415e88fab4956749fb0533"

PR = "r0"

inherit rubygems
