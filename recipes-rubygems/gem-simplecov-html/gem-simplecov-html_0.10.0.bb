SUMMARY = "simplecov-html - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "simplecov-html"
HOMEPAGE = "http://rubygems.org/gems/simplecov-html"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=23973b4bd84f8a5e081dd23bb739394d"


SRC_URI[md5sum] = "2cf56d803e1229c6e7185b33ddf33f06"
SRC_URI[sha256sum] = "0ee7c6a4f5388ef98bcc67312456dd774a4ee2720c93c28be893bedec143d1e2"

PR = "r0"

inherit rubygems
