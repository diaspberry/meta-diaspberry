SUMMARY = "omniauth-twitter - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "omniauth-twitter"
HOMEPAGE = "http://rubygems.org/gems/omniauth-twitter"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "38852fa63702cdddfb65ec5f655d14a2"
SRC_URI[sha256sum] = "63a04601a57c40f031b285c900800ba4cf49e69d772026821ef782fec3ba12c3"

PR = "r0"

inherit rubygems
