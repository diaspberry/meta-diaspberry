SUMMARY = "request_store - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "request_store"
HOMEPAGE = "http://rubygems.org/gems/request_store"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=e29905589b454c28fbff353cc99185f1"


SRC_URI[md5sum] = "ae3cca08e1d3c0760b8cb1aeaaf187ed"
SRC_URI[sha256sum] = "fb0bbd9b8514a87ae092191fc56b882d8dd5485828568a1d838c703e16e849ed"

PR = "r0"

inherit rubygems
