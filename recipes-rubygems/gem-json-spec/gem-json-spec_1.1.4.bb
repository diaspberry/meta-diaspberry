SUMMARY = "json_spec - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "json_spec"
HOMEPAGE = "http://rubygems.org/gems/json_spec"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=db984f3bd70cbb9c104e40052d2f387c"


SRC_URI[md5sum] = "8191b5051dc59dfc86a6650cdf0f295d"
SRC_URI[sha256sum] = "f0e45a0a19f83ef9b4c2bb089f6c4288240d461745aba12a84023fca45975538"

PR = "r0"

inherit rubygems
