SUMMARY = "rails-assets-emojione - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-emojione"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-emojione"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "266e9cc0a564c75c42a200f3047222ea"
SRC_URI[sha256sum] = "a230d1a5addebb5e5a447ebabae90b4a77a27dffcfd94a719c316de3f4da49c8"

PR = "r0"

inherit rubygems
