SUMMARY = "rubyzip - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rubyzip"
HOMEPAGE = "http://rubygems.org/gems/rubyzip"
SECTION = "devel/ruby"
LICENSE = "CLOSED"



SRC_URI[md5sum] = "2aef4aefee574399686427b2bfed86f2"
SRC_URI[sha256sum] = "5a2c8ac7177acadfd7f7e98d0ad5a60e9010cca6e2a48bf945f652646ab84981"

PR = "r0"

inherit rubygems
