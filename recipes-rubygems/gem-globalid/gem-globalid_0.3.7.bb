SUMMARY = "globalid - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "globalid"
HOMEPAGE = "http://rubygems.org/gems/globalid"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=77159e762fad8e7394b74cad1364b0dd"


SRC_URI[md5sum] = "ea9f7b1cd9affed81ae6071ad9ab8acd"
SRC_URI[sha256sum] = "53414b2d226b722409167098acab75e47bfeee7e3130a6852733f141fd9bf486"

PR = "r0"

inherit rubygems
