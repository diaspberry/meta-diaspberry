SUMMARY = "rails-assets-bootstrap-markdown - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails-assets-bootstrap-markdown"
HOMEPAGE = "http://rubygems.org/gems/rails-assets-bootstrap-markdown"
SECTION = "devel/ruby"
LICENSE = "CLOSED"

GEM_SRC_TLD = "http://rails-assets.org"

SRC_URI[md5sum] = "f0fb67a8d5d3d425cea9ead0a05a0875"
SRC_URI[sha256sum] = "43f2a52ee76745c290d0ee3ca98695d7eb2c1cc57a73d9abcc5d96ce93ceb1db"

PR = "r0"

inherit rubygems
