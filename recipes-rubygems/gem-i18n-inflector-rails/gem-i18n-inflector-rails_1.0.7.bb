SUMMARY = "i18n-inflector-rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "i18n-inflector-rails"
HOMEPAGE = "http://rubygems.org/gems/i18n-inflector-rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LGPL-LICENSE;md5=395e44694624b7b27173ea0c427ad53c"


SRC_URI[md5sum] = "67d89a300c7dc1b12ea01e3a2d6b6426"
SRC_URI[sha256sum] = "d3c3335472c3ed85cc39e9edace0e95b5b38ace50c7a4d822d77aa534c950430"

PR = "r0"

inherit rubygems
