SUMMARY = "rspec-expectations - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rspec-expectations"
HOMEPAGE = "http://rubygems.org/gems/rspec-expectations"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=3d96800bd9b5ffa0ed091438eaea6f01"


SRC_URI[md5sum] = "844bd2a277860056983b057f2c6c2118"
SRC_URI[sha256sum] = "fa25e00430539ad857a47be948b0536b7148f7e61076d191e3f5a11e5676782d"

PR = "r0"

inherit rubygems
