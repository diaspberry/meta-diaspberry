SUMMARY = "fog-openstack - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "fog-openstack"
HOMEPAGE = "http://rubygems.org/gems/fog-openstack"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=9cc2d895fea10643aec62c71cf2dcfcf"


SRC_URI[md5sum] = "7e6b5094c93772e8e6a90d7a95d6e0d9"
SRC_URI[sha256sum] = "5f87dde02352f317c2a778b0aed1ae19e4a42fdc2d830761e5c1868b6bf85429"

PR = "r0"

inherit rubygems
