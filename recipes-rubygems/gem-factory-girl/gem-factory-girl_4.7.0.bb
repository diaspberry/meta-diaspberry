SUMMARY = "factory_girl - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "factory_girl"
HOMEPAGE = "http://rubygems.org/gems/factory_girl"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2396da2c4b0eb36cedbf866f63d82722"


SRC_URI[md5sum] = "5b44e669a029b461364b096f06384f0b"
SRC_URI[sha256sum] = "1104a2c9ce6c0cc6adbb9c7f638755df102b5c4c0c84dbbdd50ea4f1d327f4f7"

PR = "r0"

inherit rubygems
