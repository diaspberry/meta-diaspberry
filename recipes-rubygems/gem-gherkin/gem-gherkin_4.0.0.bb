SUMMARY = "gherkin - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "gherkin"
HOMEPAGE = "http://rubygems.org/gems/gherkin"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c471c12903cfc3153b9c1a285e8830e2"


SRC_URI[md5sum] = "d4750cea2dee5f7e1fe5f8ca155efff3"
SRC_URI[sha256sum] = "f902794d86638524686f5930ad505a346ff411553aa6fe7537e43c78d29637e6"

PR = "r0"

inherit rubygems
