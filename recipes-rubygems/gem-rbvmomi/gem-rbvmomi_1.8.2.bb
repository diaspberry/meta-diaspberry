SUMMARY = "rbvmomi - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rbvmomi"
HOMEPAGE = "http://rubygems.org/gems/rbvmomi"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=9fc5b4a79db42e55eb1174273bb71e86"


SRC_URI[md5sum] = "9c9a6fce824106aa528ce30f294e7c0d"
SRC_URI[sha256sum] = "d2aabe2c08bfbc8d2fdc953a7184f28b167f30097bdb506aa8826041bf724b3e"

PR = "r0"

inherit rubygems
