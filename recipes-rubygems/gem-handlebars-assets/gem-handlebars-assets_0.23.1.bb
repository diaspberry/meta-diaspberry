SUMMARY = "handlebars_assets - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "handlebars_assets"
HOMEPAGE = "http://rubygems.org/gems/handlebars_assets"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=26f96a8e04d20ae7ad5c7303821627f8"


SRC_URI[md5sum] = "f2056f92ca03fe776442876db7ef0ae2"
SRC_URI[sha256sum] = "c47f34caa9cef5f0597078e87c43a02611615f91f578b749a5866216cb7336af"

PR = "r0"

inherit rubygems
