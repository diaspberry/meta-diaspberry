SUMMARY = "rack-pjax - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rack-pjax"
HOMEPAGE = "http://rubygems.org/gems/rack-pjax"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6ac397b3447d6fc1b7f8d4d9ae38a1da"


SRC_URI[md5sum] = "3661ad9745fb90a2d46e17322059e947"
SRC_URI[sha256sum] = "00c509fe996df4947bca846b0ae75c92977d1a8297539287f7870c4226fca9db"

PR = "r0"

inherit rubygems
