SUMMARY = "eye - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "eye"
HOMEPAGE = "http://rubygems.org/gems/eye"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6ba7df1c5ecd42b6679b3b5848e9bcf9"


SRC_URI[md5sum] = "1d9fcc5acee21e0a7fb7b094012d79b6"
SRC_URI[sha256sum] = "772e430230f01e952e28570a5f7c93c7155d18f86c25d42f9535c6abca895ca1"

PR = "r0"

inherit rubygems
