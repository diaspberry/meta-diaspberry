SUMMARY = "rails - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "rails"
HOMEPAGE = "http://rubygems.org/gems/rails"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://guides/source/_license.html.erb;md5=92c000079901837c9a49efb353440511"


SRC_URI[md5sum] = "1430ad2c0ed6dd413e20988d1aca13e7"
SRC_URI[sha256sum] = "9414bef218365d548c5e42080e70364ad2809d6263856f591ba2e393a3096dab"

PR = "r0"

inherit rubygems
