SUMMARY = "uuid - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "uuid"
HOMEPAGE = "http://rubygems.org/gems/uuid"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=48d3632c2dbfc05bcac4ebf6572b392d"


SRC_URI[md5sum] = "cb63fb3ebe0aec8930a6b91ca445d36f"
SRC_URI[sha256sum] = "7b0401e0fc4beff00833b73e528df45500ccd37ed5181f2f0768d0235eaf223f"

PR = "r0"

inherit rubygems
