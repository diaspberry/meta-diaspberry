SUMMARY = "redcarpet - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "redcarpet"
HOMEPAGE = "http://rubygems.org/gems/redcarpet"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://COPYING;md5=5f1d7f6d5d6e23c84686886580395d2f"


SRC_URI[md5sum] = "ac276e95369ff2647a1e3caf6ffda8c6"
SRC_URI[sha256sum] = "6fbf59f8fa23f84497cfb9bd1601ec35fa32f400d9034bf861c15dbbc02d6813"

PR = "r0"

inherit rubygems
