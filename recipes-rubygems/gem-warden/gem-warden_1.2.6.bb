SUMMARY = "warden - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "warden"
HOMEPAGE = "http://rubygems.org/gems/warden"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2c50fb01b7244c81047ab36238037c4a"


SRC_URI[md5sum] = "adc9b026cc4a9dc15d3b4262ab4a6be8"
SRC_URI[sha256sum] = "34e0383f0d97c07731e9841b58e54665291fc94078edad6be7228c3bb7adf711"

PR = "r0"

inherit rubygems
