SUMMARY = "simplecov - A ruby gem"
DESCRIPTION = "${SUMMARY}"
GEM_NAME = "simplecov"
HOMEPAGE = "http://rubygems.org/gems/simplecov"
SECTION = "devel/ruby"
LICENSE = "Unknown"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=b264a35dda30f90454c192a4d51e121f"


SRC_URI[md5sum] = "e3ae3768c59d8971bafa04e372052a9d"
SRC_URI[sha256sum] = "7de16175818d86c71b75deb81f141eaf1ce231244a90135815f50b6c5df6d039"

PR = "r0"

inherit rubygems
